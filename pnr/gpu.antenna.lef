

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
NAMESCASESENSITIVE ON ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO gpu 
  PIN clk 
    ANTENNAPARTIALMETALAREA 0.0182 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0504 LAYER Metal2 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via2 ;
    ANTENNAPARTIALMETALAREA 0.0446 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.198 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 15.4396 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 69.3648 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.468 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 194.392 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 878.903 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 3.08376 LAYER Via4 ;
  END clk
  PIN reset 
    ANTENNAPARTIALMETALAREA 1.3936 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 6.3 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 2.3094 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 29.3644 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 141.661 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 7.60352 LAYER Via7 ;
  END reset
  PIN start 
    ANTENNAPARTIALMETALAREA 13.846 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 62.307 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.20475 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 128.761 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 582.174 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 2.43761 LAYER Via7 ;
  END start
  PIN done 
    ANTENNADIFFAREA 0.48725 LAYER Metal2 ; 
    ANTENNAPARTIALMETALAREA 0.9942 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.4712 LAYER Metal2 ;
  END done
  PIN device_control_write_enable 
    ANTENNAPARTIALMETALAREA 0.79 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 3.555 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.26325 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 42.061 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 192.125 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 3.13191 LAYER Via7 ;
  END device_control_write_enable
  PIN device_control_data[7] 
    ANTENNAPARTIALMETALAREA 1.3052 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.8734 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 125.283 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 564.615 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 2.27436 LAYER Via3 ;
  END device_control_data[7]
  PIN device_control_data[6] 
    ANTENNAPARTIALMETALAREA 1.2572 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.6574 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 51.2658 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 232.021 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 3.71709 LAYER Via3 ;
  END device_control_data[6]
  PIN device_control_data[5] 
    ANTENNAPARTIALMETALAREA 0.0412 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1854 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 124.948 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 577.538 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 31.6145 LAYER Via3 ;
  END device_control_data[5]
  PIN device_control_data[4] 
    ANTENNAPARTIALMETALAREA 1.2858 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.7834 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 47.0607 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 213.6 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 2.27436 LAYER Via3 ;
  END device_control_data[4]
  PIN device_control_data[3] 
    ANTENNAPARTIALMETALAREA 0.9212 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.1454 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 7.8644 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 35.3556 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 288.9 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 1301.92 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 2.43162 LAYER Via4 ;
  END device_control_data[3]
  PIN device_control_data[2] 
    ANTENNAPARTIALMETALAREA 1.2676 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.733 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 46.247 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 211.015 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 2.27436 LAYER Via3 ;
  END device_control_data[2]
  PIN device_control_data[1] 
    ANTENNAPARTIALMETALAREA 0.0092 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0414 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 441.464 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 1999.97 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 28.0692 LAYER Via3 ;
  END device_control_data[1]
  PIN device_control_data[0] 
    ANTENNAPARTIALMETALAREA 0.9852 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.4334 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 14.4734 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 65.1276 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 0.0564 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2196 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 0.4512 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 2.0592 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 34.8897 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 159.631 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 3.27949 LAYER Via6 ;
  END device_control_data[0]
  PIN program_mem_read_valid[0] 
    ANTENNAPARTIALMETALAREA 0.6198 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.7576 LAYER Metal2 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via2 ;
    ANTENNAPARTIALMETALAREA 4.4904 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 20.2356 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.0564 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2196 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 0.0494 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2196 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNADIFFAREA 0.94375 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 8.8598 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 39.8664 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.14625 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 81.8725 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 392.814 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 8.96684 LAYER Via6 ;
  END program_mem_read_valid[0]
  PIN program_mem_read_address[7] 
    ANTENNAPARTIALMETALAREA 1.0446 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.6692 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 0.6488 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 2.9484 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNADIFFAREA 0.782 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 7.5284 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 33.8436 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.10395 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 112.08 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 532.649 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 10.0754 LAYER Via6 ;
  END program_mem_read_address[7]
  PIN program_mem_read_address[6] 
    ANTENNAPARTIALMETALAREA 1.0902 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 4.8744 LAYER Metal6 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via6 ;
    ANTENNADIFFAREA 0.782 LAYER Metal7 ; 
    ANTENNAPARTIALMETALAREA 0.4256 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 1.944 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.10395 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 112.514 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 534.98 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 10.1512 LAYER Via7 ;
  END program_mem_read_address[6]
  PIN program_mem_read_address[5] 
    ANTENNADIFFAREA 0.34455 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.4766 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 6.6708 LAYER Metal4 ;
  END program_mem_read_address[5]
  PIN program_mem_read_address[4] 
    ANTENNADIFFAREA 0.34455 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 1.0562 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 4.7502 LAYER Metal6 ;
  END program_mem_read_address[4]
  PIN program_mem_read_address[3] 
    ANTENNADIFFAREA 0.34455 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.992 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.4586 LAYER Metal4 ;
  END program_mem_read_address[3]
  PIN program_mem_read_address[2] 
    ANTENNADIFFAREA 0.782 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 7.9073 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 35.5104 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.10395 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 112.2 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 532.887 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 10.0891 LAYER Via6 ;
  END program_mem_read_address[2]
  PIN program_mem_read_address[1] 
    ANTENNAPARTIALMETALAREA 1.1214 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.0148 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 0.9384 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 4.2516 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNADIFFAREA 0.782 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 7.0908 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 31.8744 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 113.066 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 537.074 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 10.1413 LAYER Via6 ;
  END program_mem_read_address[1]
  PIN program_mem_read_address[0] 
    ANTENNAPARTIALMETALAREA 0.955 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.266 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 0.708 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 3.2148 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNADIFFAREA 0.782 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 7.29 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 32.7708 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.10395 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 112.304 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 533.661 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 10.0754 LAYER Via6 ;
  END program_mem_read_address[0]
  PIN program_mem_read_ready[0] 
    ANTENNAPARTIALMETALAREA 15.254 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 68.643 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0324 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 499.491 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 2251.17 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 5.08333 LAYER Via7 ;
  END program_mem_read_ready[0]
  PIN program_mem_read_data[15] 
    ANTENNAPARTIALMETALAREA 1.1436 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.1462 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 9.3466 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 41.994 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0324 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 300.235 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 1358.72 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 6.19136 LAYER Via4 ;
  END program_mem_read_data[15]
  PIN program_mem_read_data[14] 
    ANTENNAPARTIALMETALAREA 1.1376 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.085 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 192.864 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 873.333 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAMAXCUTCAR 5.82716 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 2.8262 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 12.7152 LAYER Metal4 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 367.321 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 1658.22 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAMAXCUTCAR 6.4321 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 0.0424 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2196 LAYER Metal5 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 369.938 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 1671.78 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAMAXCUTCAR 7.03704 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 3.3468 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 15.0264 LAYER Metal6 ;
    ANTENNAGATEAREA 0.0324 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 473.235 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 2135.56 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 7.03704 LAYER Via6 ;
  END program_mem_read_data[14]
  PIN program_mem_read_data[13] 
    ANTENNAPARTIALMETALAREA 1.1556 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.229 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 125.667 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 572.889 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAMAXCUTCAR 5.82716 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 3.3668 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.1164 LAYER Metal4 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 333.494 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 1506 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAMAXCUTCAR 6.4321 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 0.0264 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1476 LAYER Metal5 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 335.123 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 1515.11 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAMAXCUTCAR 7.03704 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 3.102 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 13.9248 LAYER Metal6 ;
    ANTENNAGATEAREA 0.0324 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 430.864 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 1944.89 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 7.03704 LAYER Via6 ;
  END program_mem_read_data[13]
  PIN program_mem_read_data[12] 
    ANTENNAPARTIALMETALAREA 1.158 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.211 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 77.2469 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 357.111 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAMAXCUTCAR 5.22222 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 5.1876 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 23.31 LAYER Metal4 ;
    ANTENNAGATEAREA 0.0324 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 237.358 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 1076.56 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 5.22222 LAYER Via4 ;
  END program_mem_read_data[12]
  PIN program_mem_read_data[11] 
    ANTENNAPARTIALMETALAREA 0.8892 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.0014 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 3.713 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.6428 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0324 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 140.006 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 637.333 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 5.22222 LAYER Via4 ;
  END program_mem_read_data[11]
  PIN program_mem_read_data[10] 
    ANTENNAPARTIALMETALAREA 0.9532 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.2894 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 3.5154 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.7536 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0324 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 134.944 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 614.556 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 5.22222 LAYER Via4 ;
  END program_mem_read_data[10]
  PIN program_mem_read_data[9] 
    ANTENNAPARTIALMETALAREA 0.7292 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.2814 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 3.5914 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.0956 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0324 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 142.488 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 650.444 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 5.22222 LAYER Via4 ;
  END program_mem_read_data[9]
  PIN program_mem_read_data[8] 
    ANTENNAPARTIALMETALAREA 1.6192 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.3152 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0324 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 60.2716 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 280.185 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 4.35802 LAYER Via3 ;
  END program_mem_read_data[8]
  PIN program_mem_read_data[7] 
    ANTENNAPARTIALMETALAREA 1.1444 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.1498 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 1.0074 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.4676 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 71.5556 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 329.222 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAMAXCUTCAR 5.82716 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 0.1704 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7956 LAYER Metal5 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 82.0741 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 378.333 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAMAXCUTCAR 6.4321 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 3.558 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 15.9768 LAYER Metal6 ;
    ANTENNAGATEAREA 0.0324 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 191.889 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 871.444 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.4321 LAYER Via6 ;
  END program_mem_read_data[7]
  PIN program_mem_read_data[6] 
    ANTENNAPARTIALMETALAREA 1.198 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.4486 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 94.5062 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 434.444 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAMAXCUTCAR 5.82716 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.1228 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.5184 LAYER Metal4 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 102.086 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 466.444 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAMAXCUTCAR 6.4321 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 0.0264 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1476 LAYER Metal5 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 103.716 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 475.556 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAMAXCUTCAR 7.03704 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 5.2286 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 23.526 LAYER Metal6 ;
    ANTENNAGATEAREA 0.0324 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 265.093 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 1201.67 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 7.03704 LAYER Via6 ;
  END program_mem_read_data[6]
  PIN program_mem_read_data[5] 
    ANTENNAPARTIALMETALAREA 1.0812 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.8654 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 1.5212 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 6.8112 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 101.432 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 464.185 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAMAXCUTCAR 5.5679 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 0.0584 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2916 LAYER Metal5 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 105.037 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 482.185 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAMAXCUTCAR 6.17284 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 4.6814 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 21.0636 LAYER Metal6 ;
    ANTENNAGATEAREA 0.0324 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 249.525 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 1132.3 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.4321 LAYER Via6 ;
  END program_mem_read_data[5]
  PIN program_mem_read_data[4] 
    ANTENNAPARTIALMETALAREA 0.0252 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1134 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 4.6754 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 21.0024 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 296.037 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 1339.74 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAMAXCUTCAR 5.5679 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 0.0564 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2196 LAYER Metal5 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 299.519 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 1353.3 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAMAXCUTCAR 6.17284 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 3.2808 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 14.7924 LAYER Metal6 ;
    ANTENNAGATEAREA 0.0324 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 400.778 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 1809.85 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.4321 LAYER Via6 ;
  END program_mem_read_data[4]
  PIN program_mem_read_data[3] 
    ANTENNAPARTIALMETALAREA 1.3922 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.291 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0324 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 50.9568 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 239.611 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 4.61728 LAYER Via3 ;
  END program_mem_read_data[3]
  PIN program_mem_read_data[2] 
    ANTENNAPARTIALMETALAREA 1.0332 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.6494 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 6.9294 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 31.1796 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 435.272 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 1968.41 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAMAXCUTCAR 5.5679 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 0.0564 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2196 LAYER Metal5 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 438.753 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 1981.96 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAMAXCUTCAR 6.17284 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 4.192 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 18.8928 LAYER Metal6 ;
    ANTENNAGATEAREA 0.0324 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 568.136 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 2565.07 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.4321 LAYER Via6 ;
  END program_mem_read_data[2]
  PIN program_mem_read_data[1] 
    ANTENNAPARTIALMETALAREA 1.3692 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.1614 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 6.4798 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 29.1564 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 0.0564 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2196 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 3.7964 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 17.0784 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0324 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 243.074 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 1100.56 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 7.64198 LAYER Via6 ;
  END program_mem_read_data[1]
  PIN program_mem_read_data[0] 
    ANTENNAPARTIALMETALAREA 7.5078 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 33.7536 LAYER Metal2 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via2 ;
    ANTENNAPARTIALMETALAREA 1.1456 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.184 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 76.4815 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 355.444 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAMAXCUTCAR 5.22222 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 2.219 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.9828 LAYER Metal4 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 213.457 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 971.667 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAMAXCUTCAR 5.82716 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 0.0564 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2196 LAYER Metal5 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 216.938 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 985.222 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAMAXCUTCAR 6.4321 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 3.7686 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 16.956 LAYER Metal6 ;
    ANTENNAGATEAREA 0.0324 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 333.253 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 1508.56 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 6.4321 LAYER Via6 ;
  END program_mem_read_data[0]
  PIN data_mem_read_valid[3] 
    ANTENNADIFFAREA 0.572 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 2.1532 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 9.6894 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 63.0701 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 314.682 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 9.92821 LAYER Via5 ;
  END data_mem_read_valid[3]
  PIN data_mem_read_valid[2] 
    ANTENNAPARTIALMETALAREA 0.0412 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1854 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.4892 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.1672 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 0.572 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 5.2248 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 23.5404 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 74.1823 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 364.528 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 9.77094 LAYER Via5 ;
  END data_mem_read_valid[2]
  PIN data_mem_read_valid[1] 
    ANTENNAPARTIALMETALAREA 0.0092 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0414 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 0.48725 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 6.9204 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 31.1076 LAYER Metal4 ;
  END data_mem_read_valid[1]
  PIN data_mem_read_valid[0] 
    ANTENNADIFFAREA 0.782 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 12.7434 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 57.3426 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 165.758 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 774.605 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 9.90427 LAYER Via4 ;
  END data_mem_read_valid[0]
  PIN data_mem_read_address[31] 
    ANTENNADIFFAREA 0.48725 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.477 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.1438 LAYER Metal4 ;
  END data_mem_read_address[31]
  PIN data_mem_read_address[30] 
    ANTENNADIFFAREA 0.48725 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.5378 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.4174 LAYER Metal4 ;
  END data_mem_read_address[30]
  PIN data_mem_read_address[29] 
    ANTENNADIFFAREA 0.48725 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.6138 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.7594 LAYER Metal4 ;
  END data_mem_read_address[29]
  PIN data_mem_read_address[28] 
    ANTENNADIFFAREA 0.48725 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.705 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.1698 LAYER Metal4 ;
  END data_mem_read_address[28]
  PIN data_mem_read_address[27] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.771 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.438 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 28.79 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 157.301 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.59717 LAYER Via4 ;
  END data_mem_read_address[27]
  PIN data_mem_read_address[26] 
    ANTENNADIFFAREA 0.48725 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.7506 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.375 LAYER Metal4 ;
  END data_mem_read_address[26]
  PIN data_mem_read_address[25] 
    ANTENNADIFFAREA 0.48725 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.2308 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.0674 LAYER Metal4 ;
  END data_mem_read_address[25]
  PIN data_mem_read_address[24] 
    ANTENNADIFFAREA 0.48725 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.2916 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.341 LAYER Metal4 ;
  END data_mem_read_address[24]
  PIN data_mem_read_address[23] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.1966 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.3532 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 19.0933 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 113.686 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.55273 LAYER Via4 ;
  END data_mem_read_address[23]
  PIN data_mem_read_address[22] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.1674 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.1876 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 15.8493 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 98.9713 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.59996 LAYER Via4 ;
  END data_mem_read_address[22]
  PIN data_mem_read_address[21] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.0566 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2232 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 36.3867 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 165.149 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.55273 LAYER Via4 ;
  END data_mem_read_address[21]
  PIN data_mem_read_address[20] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.0142 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.5324 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 13.3336 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 87.7883 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.63329 LAYER Via4 ;
  END data_mem_read_address[20]
  PIN data_mem_read_address[19] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.0566 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2232 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 39.3115 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 177.355 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.55273 LAYER Via4 ;
  END data_mem_read_address[19]
  PIN data_mem_read_address[18] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.1206 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.0112 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 14.6733 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 93.9278 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.55966 LAYER Via4 ;
  END data_mem_read_address[18]
  PIN data_mem_read_address[17] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.0566 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2232 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 36.5699 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 165.017 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.55273 LAYER Via4 ;
  END data_mem_read_address[17]
  PIN data_mem_read_address[16] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.1236 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.9932 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 13.9498 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 86.9958 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.5575 LAYER Via4 ;
  END data_mem_read_address[16]
  PIN data_mem_read_address[15] 
    ANTENNADIFFAREA 0.48725 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.7506 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.375 LAYER Metal4 ;
  END data_mem_read_address[15]
  PIN data_mem_read_address[14] 
    ANTENNADIFFAREA 0.48725 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.7202 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.2382 LAYER Metal4 ;
  END data_mem_read_address[14]
  PIN data_mem_read_address[13] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.239 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.044 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 23.348 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 132.816 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.55922 LAYER Via4 ;
  END data_mem_read_address[13]
  PIN data_mem_read_address[12] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.771 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.438 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 20.0536 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 117.892 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.56355 LAYER Via4 ;
  END data_mem_read_address[12]
  PIN data_mem_read_address[11] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.0566 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2232 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 18.6356 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 111.601 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.59518 LAYER Via4 ;
  END data_mem_read_address[11]
  PIN data_mem_read_address[10] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.5278 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.3436 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 16.9746 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 104.154 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.54796 LAYER Via4 ;
  END data_mem_read_address[10]
  PIN data_mem_read_address[9] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.9534 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.2588 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 16.6759 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 102.887 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.7273 LAYER Via4 ;
  END data_mem_read_address[9]
  PIN data_mem_read_address[8] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.2726 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.6952 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 15.1831 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 96.2271 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.55273 LAYER Via4 ;
  END data_mem_read_address[8]
  PIN data_mem_read_address[7] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.2726 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.6952 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 13.8722 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 90.2339 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.61597 LAYER Via4 ;
  END data_mem_read_address[7]
  PIN data_mem_read_address[6] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.0566 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2232 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 14.4299 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 92.6843 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.55922 LAYER Via4 ;
  END data_mem_read_address[6]
  PIN data_mem_read_address[5] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.0566 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2232 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 46.4494 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 209.475 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.55273 LAYER Via4 ;
  END data_mem_read_address[5]
  PIN data_mem_read_address[4] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.695 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.096 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 14.3909 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 92.5273 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.54796 LAYER Via4 ;
  END data_mem_read_address[4]
  PIN data_mem_read_address[3] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.2522 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.6322 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 18.3558 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 110.35 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.53973 LAYER Via4 ;
  END data_mem_read_address[3]
  PIN data_mem_read_address[2] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.161 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.2218 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 22.0157 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 126.93 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.56399 LAYER Via4 ;
  END data_mem_read_address[2]
  PIN data_mem_read_address[1] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.009 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.5378 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 23.0451 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 131.58 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.55273 LAYER Via4 ;
  END data_mem_read_address[1]
  PIN data_mem_read_address[0] 
    ANTENNAPARTIALMETALAREA 1.2422 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.5584 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 2.05512 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 3.0984 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 13.9716 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 22.557 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 129.4 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 8.66102 LAYER Via5 ;
  END data_mem_read_address[0]
  PIN data_mem_read_ready[3] 
    ANTENNAPARTIALMETALAREA 0.7726 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 3.4452 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 386.694 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 1741.11 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 3.08376 LAYER Via6 ;
  END data_mem_read_ready[3]
  PIN data_mem_read_ready[2] 
    ANTENNAPARTIALMETALAREA 7.0362 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 31.5972 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 467.296 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 2102.2 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 5.46914 LAYER Via6 ;
  END data_mem_read_ready[2]
  PIN data_mem_read_ready[1] 
    ANTENNAPARTIALMETALAREA 0.0566 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2232 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 0.3464 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 1.5876 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 3.8484 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 17.2836 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 72.041 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 325.472 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 1.48034 LAYER Via6 ;
  END data_mem_read_ready[1]
  PIN data_mem_read_ready[0] 
    ANTENNAPARTIALMETALAREA 0.467 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.07 LAYER Metal2 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via2 ;
    ANTENNAPARTIALMETALAREA 5.1784 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 23.3316 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 5.2668 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 23.6664 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 187.543 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 845.446 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 2.18205 LAYER Via4 ;
  END data_mem_read_ready[0]
  PIN data_mem_read_data[31] 
    ANTENNAPARTIALMETALAREA 0.1372 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6174 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.1502 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6732 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 2.347 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 10.5588 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.234 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 53.192 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 238.626 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 4.89516 LAYER Via5 ;
  END data_mem_read_data[31]
  PIN data_mem_read_data[30] 
    ANTENNAPARTIALMETALAREA 2.0076 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 9.0342 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.234 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 47.9667 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 218.479 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 3.27692 LAYER Via5 ;
  END data_mem_read_data[30]
  PIN data_mem_read_data[29] 
    ANTENNAPARTIALMETALAREA 3.3556 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 15.1236 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1917 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 53.2482 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 247.461 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAMAXCUTCAR 5.0126 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 0.4558 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 2.0484 LAYER Metal6 ;
    ANTENNAGATEAREA 0.22095 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 55.3111 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 256.732 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 5.0126 LAYER Via6 ;
  END data_mem_read_data[29]
  PIN data_mem_read_data[28] 
    ANTENNAPARTIALMETALAREA 1.7494 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.8696 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 62.7188 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 284.062 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAMAXCUTCAR 2.6094 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 1.2082 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.3712 LAYER Metal4 ;
    ANTENNAGATEAREA 0.234 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 67.8821 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 307.015 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 3.02285 LAYER Via4 ;
  END data_mem_read_data[28]
  PIN data_mem_read_data[27] 
    ANTENNAPARTIALMETALAREA 0.4396 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 1.9782 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.26325 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 37.7498 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 172.072 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 3.28509 LAYER Via5 ;
  END data_mem_read_data[27]
  PIN data_mem_read_data[26] 
    ANTENNAPARTIALMETALAREA 1.078 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.851 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.1988 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.8604 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 0.5704 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 2.5956 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.26325 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 25.0721 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 113.579 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 4.35432 LAYER Via5 ;
  END data_mem_read_data[26]
  PIN data_mem_read_data[25] 
    ANTENNAPARTIALMETALAREA 0.7612 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.4254 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.732 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.2256 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 41.4231 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 186.277 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAMAXCUTCAR 3.21795 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 0.1224 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.5796 LAYER Metal5 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 43.5154 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 196.185 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAMAXCUTCAR 3.38547 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 0.6092 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 2.7072 LAYER Metal6 ;
    ANTENNAGATEAREA 0.234 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 46.1188 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 207.754 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 3.71823 LAYER Via6 ;
  END data_mem_read_data[25]
  PIN data_mem_read_data[24] 
    ANTENNAPARTIALMETALAREA 1.5428 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.9426 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.6548 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.9124 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 22.7803 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 103.262 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAMAXCUTCAR 2.6094 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 0.0564 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2196 LAYER Metal5 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 23.7444 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 107.015 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAMAXCUTCAR 2.77692 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 1.0926 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 4.914 LAYER Metal6 ;
    ANTENNAGATEAREA 0.234 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 28.4137 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 128.015 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 3.00028 LAYER Via6 ;
  END data_mem_read_data[24]
  PIN data_mem_read_data[23] 
    ANTENNAPARTIALMETALAREA 2.614 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 11.763 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.234 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 40.8103 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 184.418 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 4.6265 LAYER Via5 ;
  END data_mem_read_data[23]
  PIN data_mem_read_data[22] 
    ANTENNAPARTIALMETALAREA 0.2004 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.9018 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.7492 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.3372 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 1.8952 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 8.5572 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.234 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 29.4538 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 133.933 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 4.2698 LAYER Via5 ;
  END data_mem_read_data[22]
  PIN data_mem_read_data[21] 
    ANTENNAPARTIALMETALAREA 2.9816 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 13.383 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 64.5185 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 292.277 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAMAXCUTCAR 2.80912 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 0.8692 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 3.8772 LAYER Metal6 ;
    ANTENNAGATEAREA 0.234 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 68.233 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 308.846 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 2.80912 LAYER Via6 ;
  END data_mem_read_data[21]
  PIN data_mem_read_data[20] 
    ANTENNAPARTIALMETALAREA 0.3876 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.773 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.442 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.9548 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 1.2744 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 5.7636 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.234 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 22.2619 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 104.047 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.39436 LAYER Via5 ;
  END data_mem_read_data[20]
  PIN data_mem_read_data[19] 
    ANTENNAPARTIALMETALAREA 1.3188 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 5.9346 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.26325 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 27.4135 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 124.988 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 3.70606 LAYER Via5 ;
  END data_mem_read_data[19]
  PIN data_mem_read_data[18] 
    ANTENNAPARTIALMETALAREA 0.0754 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3078 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.0328 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1764 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 0.1086 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.486 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 0.9604 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 4.2876 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.26325 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 27.9085 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 127.812 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 3.86591 LAYER Via6 ;
  END data_mem_read_data[18]
  PIN data_mem_read_data[17] 
    ANTENNAPARTIALMETALAREA 1.0122 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 4.5522 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.234 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 56.2687 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 253.762 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 3.57721 LAYER Via5 ;
  END data_mem_read_data[17]
  PIN data_mem_read_data[16] 
    ANTENNAPARTIALMETALAREA 1.6052 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.2234 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.7944 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.5064 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 24.9231 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 112.872 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAMAXCUTCAR 2.50598 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 0.0584 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2916 LAYER Metal5 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 25.9214 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 117.856 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAMAXCUTCAR 2.6735 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 1.0044 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 4.4856 LAYER Metal6 ;
    ANTENNAGATEAREA 0.234 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 30.2137 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 137.026 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 3.01584 LAYER Via6 ;
  END data_mem_read_data[16]
  PIN data_mem_read_data[15] 
    ANTENNAPARTIALMETALAREA 0.0092 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0414 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 2.45 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 10.9908 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.117 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 53.9427 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 246.779 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 3.53504 LAYER Via6 ;
  END data_mem_read_data[15]
  PIN data_mem_read_data[14] 
    ANTENNAPARTIALMETALAREA 1.0492 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.7214 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 2.0108 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.0144 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 0.8888 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 4.0284 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.117 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 17.6613 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 83.6205 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.75983 LAYER Via5 ;
  END data_mem_read_data[14]
  PIN data_mem_read_data[13] 
    ANTENNAPARTIALMETALAREA 0.0892 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4014 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 2.054 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 9.2088 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1755 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 33.0254 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 152.221 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 2.72165 LAYER Via6 ;
  END data_mem_read_data[13]
  PIN data_mem_read_data[12] 
    ANTENNAPARTIALMETALAREA 0.1052 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4734 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 2.0396 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.144 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 1.4792 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 6.6852 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.117 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 21.7986 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 102.328 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.69373 LAYER Via5 ;
  END data_mem_read_data[12]
  PIN data_mem_read_data[11] 
    ANTENNAPARTIALMETALAREA 0.0564 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2538 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.14625 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 31.2402 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 140.878 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.66991 LAYER Via5 ;
  END data_mem_read_data[11]
  PIN data_mem_read_data[10] 
    ANTENNAPARTIALMETALAREA 0.0412 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1854 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 2.2068 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 9.8964 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.14625 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 35.5145 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 163.971 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 2.93943 LAYER Via6 ;
  END data_mem_read_data[10]
  PIN data_mem_read_data[9] 
    ANTENNAPARTIALMETALAREA 1.3594 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.1146 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 27.3709 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 123.769 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAMAXCUTCAR 1.28889 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.0328 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1764 LAYER Metal4 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 27.9316 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 126.785 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAMAXCUTCAR 1.45641 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 0.539 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 2.4228 LAYER Metal5 ;
    ANTENNAGATEAREA 0.14625 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 31.6171 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 143.351 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 3.37407 LAYER Via5 ;
  END data_mem_read_data[9]
  PIN data_mem_read_data[8] 
    ANTENNAPARTIALMETALAREA 1.4004 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 6.3018 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 2.2622 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 10.1772 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.117 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 31.6379 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 146.021 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 2.62023 LAYER Via6 ;
  END data_mem_read_data[8]
  PIN data_mem_read_data[7] 
    ANTENNAPARTIALMETALAREA 0.0412 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1854 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.062 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2448 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 2.5512 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 11.5092 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1755 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 39.5578 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 179.579 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.59174 LAYER Via5 ;
  END data_mem_read_data[7]
  PIN data_mem_read_data[6] 
    ANTENNAPARTIALMETALAREA 0.3756 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.6902 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.062 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2448 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 1.95065 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 8.7696 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 2.7044 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 12.1356 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1755 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 33.0621 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 150.513 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 2.5359 LAYER Via6 ;
  END data_mem_read_data[6]
  PIN data_mem_read_data[5] 
    ANTENNAPARTIALMETALAREA 0.1532 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6894 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.7468 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.3264 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 2.1064 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 9.5076 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 44.1299 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 200.779 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAMAXCUTCAR 2.36239 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 2.1322 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 9.5292 LAYER Metal6 ;
    ANTENNAGATEAREA 0.1755 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 56.2792 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 255.077 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 3.56809 LAYER Via6 ;
  END data_mem_read_data[5]
  PIN data_mem_read_data[4] 
    ANTENNAPARTIALMETALAREA 1.5924 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 7.1658 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 1.3244 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 5.9256 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1755 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 27.894 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 127.703 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 2.44074 LAYER Via6 ;
  END data_mem_read_data[4]
  PIN data_mem_read_data[3] 
    ANTENNAPARTIALMETALAREA 2.1764 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.8226 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 61.6889 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 279.774 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAMAXCUTCAR 2.19487 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 2.4676 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.0016 LAYER Metal4 ;
    ANTENNAGATEAREA 0.117 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 82.7795 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 373.805 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAMAXCUTCAR 2.75726 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 0.2526 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 1.134 LAYER Metal5 ;
    ANTENNAGATEAREA 0.1755 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 84.2188 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 380.267 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.75726 LAYER Via5 ;
  END data_mem_read_data[3]
  PIN data_mem_read_data[2] 
    ANTENNAPARTIALMETALAREA 1.8788 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 8.4546 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1755 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 37.8724 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 173.118 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.56182 LAYER Via5 ;
  END data_mem_read_data[2]
  PIN data_mem_read_data[1] 
    ANTENNAPARTIALMETALAREA 0.6812 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.0654 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.778 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.4668 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 2.0654 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 9.3492 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1755 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 49.4473 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 224.297 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 3.36752 LAYER Via5 ;
  END data_mem_read_data[1]
  PIN data_mem_read_data[0] 
    ANTENNAPARTIALMETALAREA 0.3276 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.4742 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.0772 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3132 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 1.495 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 6.7536 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.117 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 53.3026 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 241.426 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAMAXCUTCAR 2.94872 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 0.5666 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 2.484 LAYER Metal6 ;
    ANTENNAGATEAREA 0.1755 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 56.5311 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 255.579 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 3.03248 LAYER Via6 ;
  END data_mem_read_data[0]
  PIN data_mem_write_valid[3] 
    ANTENNADIFFAREA 0.34455 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 0.9212 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 4.1454 LAYER Metal5 ;
  END data_mem_write_valid[3]
  PIN data_mem_write_valid[2] 
    ANTENNAPARTIALMETALAREA 0.0262 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0864 LAYER Metal2 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via2 ;
    ANTENNAPARTIALMETALAREA 0.0424 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2196 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.0564 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2196 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 0.0494 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2196 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNADIFFAREA 0.48725 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 4.5904 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 20.6856 LAYER Metal6 ;
  END data_mem_write_valid[2]
  PIN data_mem_write_valid[1] 
    ANTENNADIFFAREA 2.05512 LAYER Metal2 ; 
    ANTENNAPARTIALMETALAREA 1.1434 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.1084 LAYER Metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal2 ; 
    ANTENNAMAXAREACAR 12.8374 LAYER Metal2 ;
    ANTENNAMAXSIDEAREACAR 85.3971 LAYER Metal2 ;
    ANTENNAMAXCUTCAR 8.48386 LAYER Via2 ;
  END data_mem_write_valid[1]
  PIN data_mem_write_valid[0] 
    ANTENNADIFFAREA 0.34455 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 1.0476 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 4.7142 LAYER Metal5 ;
  END data_mem_write_valid[0]
  PIN data_mem_write_address[31] 
    ANTENNADIFFAREA 0.64145 LAYER Metal7 ; 
    ANTENNAPARTIALMETALAREA 9.0912 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 40.9392 LAYER Metal7 ;
  END data_mem_write_address[31]
  PIN data_mem_write_address[30] 
    ANTENNADIFFAREA 0.48725 LAYER Metal2 ; 
    ANTENNAPARTIALMETALAREA 6.8863 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 30.9762 LAYER Metal2 ;
  END data_mem_write_address[30]
  PIN data_mem_write_address[29] 
    ANTENNAPARTIALMETALAREA 0.695 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 3.096 LAYER Metal2 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via2 ;
    ANTENNAPARTIALMETALAREA 7.3224 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 32.9796 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 0.64145 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 4.3646 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 19.638 LAYER Metal4 ;
  END data_mem_write_address[29]
  PIN data_mem_write_address[28] 
    ANTENNAPARTIALMETALAREA 0.7528 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 3.3876 LAYER Metal2 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via2 ;
    ANTENNAPARTIALMETALAREA 0.0382 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1692 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 3.2502 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.6232 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 0.0584 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2916 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNADIFFAREA 0.572 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 3.631 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 16.3368 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 83.0564 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 403.995 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 10.106 LAYER Via6 ;
  END data_mem_write_address[28]
  PIN data_mem_write_address[27] 
    ANTENNAPARTIALMETALAREA 1.395 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 6.246 LAYER Metal2 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via2 ;
    ANTENNAPARTIALMETALAREA 0.1544 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7236 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 0.34455 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.1276 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.04 LAYER Metal4 ;
  END data_mem_write_address[27]
  PIN data_mem_write_address[26] 
    ANTENNAPARTIALMETALAREA 0.6342 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.8224 LAYER Metal2 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via2 ;
    ANTENNAPARTIALMETALAREA 1.5464 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.9876 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 2.6508 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 11.8944 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 0.48725 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 1.0968 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 4.9644 LAYER Metal5 ;
  END data_mem_write_address[26]
  PIN data_mem_write_address[25] 
    ANTENNAPARTIALMETALAREA 0.543 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.412 LAYER Metal2 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via2 ;
    ANTENNAPARTIALMETALAREA 2.2504 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.1556 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.0382 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1692 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 0.0494 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2196 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNADIFFAREA 0.48725 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 3.4214 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 15.3936 LAYER Metal6 ;
  END data_mem_write_address[25]
  PIN data_mem_write_address[24] 
    ANTENNADIFFAREA 0.48725 LAYER Metal2 ; 
    ANTENNAPARTIALMETALAREA 1.289 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.8266 LAYER Metal2 ;
  END data_mem_write_address[24]
  PIN data_mem_write_address[23] 
    ANTENNAPARTIALMETALAREA 0.7558 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 3.3696 LAYER Metal2 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via2 ;
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 3.4968 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 15.7644 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 24.6851 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 138.821 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.52353 LAYER Via3 ;
  END data_mem_write_address[23]
  PIN data_mem_write_address[22] 
    ANTENNADIFFAREA 2.05512 LAYER Metal2 ; 
    ANTENNAPARTIALMETALAREA 1.1934 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.3334 LAYER Metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal2 ; 
    ANTENNAMAXAREACAR 13.2608 LAYER Metal2 ;
    ANTENNAMAXSIDEAREACAR 87.3128 LAYER Metal2 ;
    ANTENNAMAXCUTCAR 8.4726 LAYER Via2 ;
  END data_mem_write_address[22]
  PIN data_mem_write_address[21] 
    ANTENNADIFFAREA 2.05512 LAYER Metal2 ; 
    ANTENNAPARTIALMETALAREA 1.1522 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.1192 LAYER Metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.23085 LAYER Metal2 ; 
    ANTENNAMAXAREACAR 13.413 LAYER Metal2 ;
    ANTENNAMAXSIDEAREACAR 87.8545 LAYER Metal2 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via2 ;
    ANTENNAMAXCUTCAR 8.50682 LAYER Via2 ;
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.1064 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.5076 LAYER Metal3 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 13.8437 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 89.9091 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.50682 LAYER Via3 ;
  END data_mem_write_address[21]
  PIN data_mem_write_address[20] 
    ANTENNADIFFAREA 2.05512 LAYER Metal2 ; 
    ANTENNAPARTIALMETALAREA 1.093 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.8528 LAYER Metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal2 ; 
    ANTENNAMAXAREACAR 12.6939 LAYER Metal2 ;
    ANTENNAMAXSIDEAREACAR 84.8173 LAYER Metal2 ;
    ANTENNAMAXCUTCAR 8.53411 LAYER Via2 ;
  END data_mem_write_address[20]
  PIN data_mem_write_address[19] 
    ANTENNAPARTIALMETALAREA 1.134 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.0688 LAYER Metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal2 ; 
    ANTENNAMAXAREACAR 72.5525 LAYER Metal2 ;
    ANTENNAMAXSIDEAREACAR 327.056 LAYER Metal2 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via2 ;
    ANTENNAMAXCUTCAR 3.76235 LAYER Via2 ;
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.2526 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.134 LAYER Metal3 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 73.5749 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 331.646 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.51505 LAYER Via3 ;
  END data_mem_write_address[19]
  PIN data_mem_write_address[18] 
    ANTENNAPARTIALMETALAREA 1.2858 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.7204 LAYER Metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal2 ; 
    ANTENNAMAXAREACAR 81.6852 LAYER Metal2 ;
    ANTENNAMAXSIDEAREACAR 367.833 LAYER Metal2 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via2 ;
    ANTENNAMAXCUTCAR 3.52469 LAYER Via2 ;
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.2984 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3716 LAYER Metal3 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 82.893 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 373.385 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.52632 LAYER Via3 ;
  END data_mem_write_address[18]
  PIN data_mem_write_address[17] 
    ANTENNADIFFAREA 2.05512 LAYER Metal2 ; 
    ANTENNAPARTIALMETALAREA 1.1504 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.1084 LAYER Metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal2 ; 
    ANTENNAMAXAREACAR 13.098 LAYER Metal2 ;
    ANTENNAMAXSIDEAREACAR 86.4346 LAYER Metal2 ;
    ANTENNAMAXCUTCAR 8.48386 LAYER Via2 ;
  END data_mem_write_address[17]
  PIN data_mem_write_address[16] 
    ANTENNADIFFAREA 2.05512 LAYER Metal2 ; 
    ANTENNAPARTIALMETALAREA 1.1508 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.1444 LAYER Metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.23085 LAYER Metal2 ; 
    ANTENNAMAXAREACAR 13.407 LAYER Metal2 ;
    ANTENNAMAXSIDEAREACAR 87.9636 LAYER Metal2 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via2 ;
    ANTENNAMAXCUTCAR 8.50682 LAYER Via2 ;
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.1108 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4644 LAYER Metal3 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 13.8555 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 89.8434 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.50682 LAYER Via3 ;
  END data_mem_write_address[16]
  PIN data_mem_write_address[15] 
    ANTENNADIFFAREA 1.7432 LAYER Metal2 ; 
    ANTENNAPARTIALMETALAREA 1.1086 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.9572 LAYER Metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1782 LAYER Metal2 ; 
    ANTENNAMAXAREACAR 18.3878 LAYER Metal2 ;
    ANTENNAMAXSIDEAREACAR 125.744 LAYER Metal2 ;
    ANTENNAMAXCUTCAR 12.2272 LAYER Via2 ;
  END data_mem_write_address[15]
  PIN data_mem_write_address[14] 
    ANTENNAPARTIALMETALAREA 1.0934 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.8888 LAYER Metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal2 ; 
    ANTENNAMAXAREACAR 70.0463 LAYER Metal2 ;
    ANTENNAMAXSIDEAREACAR 315.944 LAYER Metal2 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via2 ;
    ANTENNAMAXCUTCAR 3.76235 LAYER Via2 ;
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.2664 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.2276 LAYER Metal3 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 71.1246 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 320.913 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.52632 LAYER Via3 ;
  END data_mem_write_address[14]
  PIN data_mem_write_address[13] 
    ANTENNADIFFAREA 2.05512 LAYER Metal2 ; 
    ANTENNAPARTIALMETALAREA 1.1396 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.1282 LAYER Metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal2 ; 
    ANTENNAMAXAREACAR 13.0542 LAYER Metal2 ;
    ANTENNAMAXSIDEAREACAR 86.5147 LAYER Metal2 ;
    ANTENNAMAXCUTCAR 8.48386 LAYER Via2 ;
  END data_mem_write_address[13]
  PIN data_mem_write_address[12] 
    ANTENNADIFFAREA 2.05512 LAYER Metal2 ; 
    ANTENNAPARTIALMETALAREA 1.357 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 6.075 LAYER Metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal2 ; 
    ANTENNAMAXAREACAR 13.923 LAYER Metal2 ;
    ANTENNAMAXSIDEAREACAR 90.3147 LAYER Metal2 ;
    ANTENNAMAXCUTCAR 8.4726 LAYER Via2 ;
  END data_mem_write_address[12]
  PIN data_mem_write_address[11] 
    ANTENNADIFFAREA 2.05512 LAYER Metal2 ; 
    ANTENNAPARTIALMETALAREA 1.216 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.472 LAYER Metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal2 ; 
    ANTENNAMAXAREACAR 13.3522 LAYER Metal2 ;
    ANTENNAMAXSIDEAREACAR 87.8739 LAYER Metal2 ;
    ANTENNAMAXCUTCAR 8.4726 LAYER Via2 ;
  END data_mem_write_address[11]
  PIN data_mem_write_address[10] 
    ANTENNAPARTIALMETALAREA 0.9686 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.3272 LAYER Metal2 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via2 ;
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.1544 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7236 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 9.25612 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 69.5281 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.52632 LAYER Via3 ;
  END data_mem_write_address[10]
  PIN data_mem_write_address[9] 
    ANTENNADIFFAREA 2.05512 LAYER Metal2 ; 
    ANTENNAPARTIALMETALAREA 1.2782 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.6862 LAYER Metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal2 ; 
    ANTENNAMAXAREACAR 13.3557 LAYER Metal2 ;
    ANTENNAMAXSIDEAREACAR 87.6186 LAYER Metal2 ;
    ANTENNAMAXCUTCAR 8.48386 LAYER Via2 ;
  END data_mem_write_address[9]
  PIN data_mem_write_address[8] 
    ANTENNADIFFAREA 2.05512 LAYER Metal2 ; 
    ANTENNAPARTIALMETALAREA 1.0924 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.9158 LAYER Metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal2 ; 
    ANTENNAMAXAREACAR 12.8632 LAYER Metal2 ;
    ANTENNAMAXSIDEAREACAR 85.655 LAYER Metal2 ;
    ANTENNAMAXCUTCAR 8.48386 LAYER Via2 ;
  END data_mem_write_address[8]
  PIN data_mem_write_address[7] 
    ANTENNADIFFAREA 0.572 LAYER Metal2 ; 
    ANTENNAPARTIALMETALAREA 1.135 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.0706 LAYER Metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal2 ; 
    ANTENNAMAXAREACAR 22.2028 LAYER Metal2 ;
    ANTENNAMAXSIDEAREACAR 129.964 LAYER Metal2 ;
    ANTENNAMAXCUTCAR 9.4359 LAYER Via2 ;
  END data_mem_write_address[7]
  PIN data_mem_write_address[6] 
    ANTENNADIFFAREA 0.572 LAYER Metal2 ; 
    ANTENNAPARTIALMETALAREA 1.1432 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.139 LAYER Metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal2 ; 
    ANTENNAMAXAREACAR 22.2963 LAYER Metal2 ;
    ANTENNAMAXSIDEAREACAR 130.744 LAYER Metal2 ;
    ANTENNAMAXCUTCAR 9.4359 LAYER Via2 ;
  END data_mem_write_address[6]
  PIN data_mem_write_address[5] 
    ANTENNADIFFAREA 2.05512 LAYER Metal2 ; 
    ANTENNAPARTIALMETALAREA 1.1664 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.1804 LAYER Metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal2 ; 
    ANTENNAMAXAREACAR 12.9258 LAYER Metal2 ;
    ANTENNAMAXSIDEAREACAR 85.6739 LAYER Metal2 ;
    ANTENNAMAXCUTCAR 8.48386 LAYER Via2 ;
  END data_mem_write_address[5]
  PIN data_mem_write_address[4] 
    ANTENNADIFFAREA 2.05512 LAYER Metal2 ; 
    ANTENNAPARTIALMETALAREA 1.2314 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.5098 LAYER Metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.23085 LAYER Metal2 ; 
    ANTENNAMAXAREACAR 13.7643 LAYER Metal2 ;
    ANTENNAMAXSIDEAREACAR 89.5919 LAYER Metal2 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via2 ;
    ANTENNAMAXCUTCAR 8.51505 LAYER Via2 ;
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.2136 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.99 LAYER Metal3 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 14.5856 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 93.3982 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.51505 LAYER Via3 ;
  END data_mem_write_address[4]
  PIN data_mem_write_address[3] 
    ANTENNADIFFAREA 2.05512 LAYER Metal2 ; 
    ANTENNAPARTIALMETALAREA 1.1042 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.9032 LAYER Metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.23085 LAYER Metal2 ; 
    ANTENNAMAXAREACAR 13.3498 LAYER Metal2 ;
    ANTENNAMAXSIDEAREACAR 87.692 LAYER Metal2 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via2 ;
    ANTENNAMAXCUTCAR 8.69396 LAYER Via2 ;
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.2846 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.278 LAYER Metal3 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 14.444 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 92.6055 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.69396 LAYER Via3 ;
  END data_mem_write_address[3]
  PIN data_mem_write_address[2] 
    ANTENNADIFFAREA 2.05512 LAYER Metal2 ; 
    ANTENNAPARTIALMETALAREA 1.0798 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.8564 LAYER Metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal2 ; 
    ANTENNAMAXAREACAR 12.5825 LAYER Metal2 ;
    ANTENNAMAXSIDEAREACAR 84.3763 LAYER Metal2 ;
    ANTENNAMAXCUTCAR 8.47347 LAYER Via2 ;
  END data_mem_write_address[2]
  PIN data_mem_write_address[1] 
    ANTENNADIFFAREA 2.05512 LAYER Metal2 ; 
    ANTENNAPARTIALMETALAREA 1.154 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.1588 LAYER Metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal2 ; 
    ANTENNAMAXAREACAR 13.394 LAYER Metal2 ;
    ANTENNAMAXSIDEAREACAR 85.5389 LAYER Metal2 ;
    ANTENNAMAXCUTCAR 9.62735 LAYER Via2 ;
  END data_mem_write_address[1]
  PIN data_mem_write_address[0] 
    ANTENNADIFFAREA 2.05512 LAYER Metal7 ; 
    ANTENNAPARTIALMETALAREA 0.0572 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2574 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 17.9993 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 108.705 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 8.67225 LAYER Via7 ;
  END data_mem_write_address[0]
  PIN data_mem_write_data[31] 
    ANTENNADIFFAREA 0.48725 LAYER Metal2 ; 
    ANTENNAPARTIALMETALAREA 7.1498 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 32.1714 LAYER Metal2 ;
  END data_mem_write_data[31]
  PIN data_mem_write_data[30] 
    ANTENNADIFFAREA 0.48725 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.7424 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.8984 LAYER Metal3 ;
  END data_mem_write_data[30]
  PIN data_mem_write_data[29] 
    ANTENNAPARTIALMETALAREA 2.4252 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.9134 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 0.572 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 6.4468 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 28.9764 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 94.8031 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 446.692 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 9.70484 LAYER Via4 ;
  END data_mem_write_data[29]
  PIN data_mem_write_data[28] 
    ANTENNAPARTIALMETALAREA 2.2284 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.0278 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 0.572 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 5.8868 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 26.4564 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 93.6131 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 452.656 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 9.36638 LAYER Via4 ;
  END data_mem_write_data[28]
  PIN data_mem_write_data[27] 
    ANTENNADIFFAREA 0.241025 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.1952 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.9072 LAYER Metal3 ;
  END data_mem_write_data[27]
  PIN data_mem_write_data[26] 
    ANTENNADIFFAREA 0.572 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 4.4052 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 19.881 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 84.6974 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 411.677 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 9.76068 LAYER Via3 ;
  END data_mem_write_data[26]
  PIN data_mem_write_data[25] 
    ANTENNAPARTIALMETALAREA 2.7084 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.1878 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 4.2116 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 18.918 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 0.572 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 1.0336 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 4.68 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 26.5755 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 149.923 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 9.82678 LAYER Via5 ;
  END data_mem_write_data[25]
  PIN data_mem_write_data[24] 
    ANTENNAPARTIALMETALAREA 2.0524 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.2358 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 0.572 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 3.7514 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.8444 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 57.1259 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 287.4 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 9.7151 LAYER Via4 ;
  END data_mem_write_data[24]
  PIN data_mem_write_data[23] 
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.106 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.0058 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 12.8548 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 85.8656 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.52198 LAYER Via3 ;
  END data_mem_write_data[23]
  PIN data_mem_write_data[22] 
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.1212 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.5454 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 37.1911 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 182.926 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 30.0719 LAYER Via3 ;
  END data_mem_write_data[22]
  PIN data_mem_write_data[21] 
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.9636 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.365 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 15.7188 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 98.4749 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.50638 LAYER Via3 ;
  END data_mem_write_data[21]
  PIN data_mem_write_data[20] 
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.4324 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.4458 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 16.844 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 103.62 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.84712 LAYER Via3 ;
  END data_mem_write_data[20]
  PIN data_mem_write_data[19] 
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.9372 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.2174 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 14.505 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 92.923 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.51227 LAYER Via3 ;
  END data_mem_write_data[19]
  PIN data_mem_write_data[18] 
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.9692 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.3614 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 13.7229 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 89.3854 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.52353 LAYER Via3 ;
  END data_mem_write_data[18]
  PIN data_mem_write_data[17] 
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.0092 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0414 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 49.559 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 246.29 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 49.8792 LAYER Via3 ;
  END data_mem_write_data[17]
  PIN data_mem_write_data[16] 
    ANTENNADIFFAREA 1.7432 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.9372 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.2174 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1782 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 18.968 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 128.34 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 12.2822 LAYER Via3 ;
  END data_mem_write_data[16]
  PIN data_mem_write_data[15] 
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.9532 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.2894 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 13.1023 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 86.7736 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.58288 LAYER Via3 ;
  END data_mem_write_data[15]
  PIN data_mem_write_data[14] 
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.9052 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.0734 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 12.6958 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 84.829 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.57829 LAYER Via3 ;
  END data_mem_write_data[14]
  PIN data_mem_write_data[13] 
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.5052 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.2734 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 12.7967 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 86.0168 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 10.1137 LAYER Via3 ;
  END data_mem_write_data[13]
  PIN data_mem_write_data[12] 
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.2396 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.5782 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 21.4806 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 98.857 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.52632 LAYER Via3 ;
  END data_mem_write_data[12]
  PIN data_mem_write_data[11] 
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.1372 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6174 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 24.8231 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 124.065 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 23.6616 LAYER Via3 ;
  END data_mem_write_data[11]
  PIN data_mem_write_data[10] 
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.1532 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6894 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 13.9073 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 91.587 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 11.1928 LAYER Via3 ;
  END data_mem_write_data[10]
  PIN data_mem_write_data[9] 
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.2218 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.4954 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 20.4702 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 94.2996 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.52632 LAYER Via3 ;
  END data_mem_write_data[9]
  PIN data_mem_write_data[8] 
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.9196 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.1382 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 18.824 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 112.486 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.51227 LAYER Via3 ;
  END data_mem_write_data[8]
  PIN data_mem_write_data[7] 
    ANTENNAPARTIALMETALAREA 1.3852 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.2334 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 0.572 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 4.6388 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 20.8404 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 65.1607 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 324.564 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 9.49003 LAYER Via4 ;
  END data_mem_write_data[7]
  PIN data_mem_write_data[6] 
    ANTENNADIFFAREA 0.572 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.0216 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.6548 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 22.9858 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 128.979 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 9.60342 LAYER Via3 ;
  END data_mem_write_data[6]
  PIN data_mem_write_data[5] 
    ANTENNADIFFAREA 0.572 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.1792 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.8352 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 77.8917 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 361.149 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 21.657 LAYER Via3 ;
  END data_mem_write_data[5]
  PIN data_mem_write_data[4] 
    ANTENNADIFFAREA 0.572 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.0216 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.126 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 82.1128 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 382.544 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 24.9185 LAYER Via3 ;
  END data_mem_write_data[4]
  PIN data_mem_write_data[3] 
    ANTENNAPARTIALMETALAREA 0.9212 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.1454 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 0.572 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 4.4412 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 19.9512 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 71.216 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 322.318 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 9.43006 LAYER Via4 ;
  END data_mem_write_data[3]
  PIN data_mem_write_data[2] 
    ANTENNADIFFAREA 0.572 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.3888 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.3072 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 186.993 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 845.805 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 9.5094 LAYER Via3 ;
  END data_mem_write_data[2]
  PIN data_mem_write_data[1] 
    ANTENNADIFFAREA 0.572 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.9918 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.4892 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 24.1698 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 139.503 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 9.54758 LAYER Via3 ;
  END data_mem_write_data[1]
  PIN data_mem_write_data[0] 
    ANTENNADIFFAREA 0.572 LAYER Metal2 ; 
    ANTENNAPARTIALMETALAREA 5.945 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 26.7156 LAYER Metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal2 ; 
    ANTENNAMAXAREACAR 77.0177 LAYER Metal2 ;
    ANTENNAMAXSIDEAREACAR 376.631 LAYER Metal2 ;
    ANTENNAMAXCUTCAR 9.4359 LAYER Via2 ;
  END data_mem_write_data[0]
  PIN data_mem_write_ready[3] 
    ANTENNAPARTIALMETALAREA 5.8052 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 26.0892 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 104.506 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 477.205 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 2.29402 LAYER Via4 ;
  END data_mem_write_ready[3]
  PIN data_mem_write_ready[2] 
    ANTENNAPARTIALMETALAREA 0.695 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.096 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 6.8584 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 30.8916 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 6.1876 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 27.81 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 227.33 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 1023.86 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 2.94017 LAYER Via6 ;
  END data_mem_write_ready[2]
  PIN data_mem_write_ready[1] 
    ANTENNAPARTIALMETALAREA 0.0566 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2232 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 0.9384 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 4.2516 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 6.9166 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 31.122 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 243.556 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 1098.24 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 2.38974 LAYER Via6 ;
  END data_mem_write_ready[1]
  PIN data_mem_write_ready[0] 
    ANTENNAPARTIALMETALAREA 5.5922 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 25.0992 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 100.954 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 454.923 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 2.17778 LAYER Via4 ;
  END data_mem_write_ready[0]
END gpu

END LIBRARY
