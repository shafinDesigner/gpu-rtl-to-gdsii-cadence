

# LEF File for Accumulated Process Antenna Effects at the Boundary Pins
# *********************************************************************

VERSION 5.5 ;
NAMESCASESENSITIVE ON ;
DIVIDERCHAR "/" ;
BUSBITCHARS "[]" ;

MACRO gpu 
  PIN clk 
    ANTENNAPARTIALMETALAREA 0.0182 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0504 LAYER Metal2 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via2 ;
    ANTENNAPARTIALMETALAREA 0.0446 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.198 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 14.5578 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 65.3472 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.1134 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 471.579 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 2125.44 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 4.54321 LAYER Via4 ;
  END clk
  PIN reset 
    ANTENNAPARTIALMETALAREA 0.1372 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6174 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.52965 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 34.6488 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 158.805 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 3.4645 LAYER Via7 ;
  END reset
  PIN start 
    ANTENNAPARTIALMETALAREA 15.1108 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 67.9986 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.20475 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 106.227 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 482.541 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 2.55726 LAYER Via7 ;
  END start
  PIN done 
    ANTENNADIFFAREA 0.48725 LAYER Metal2 ; 
    ANTENNAPARTIALMETALAREA 2.8046 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 12.618 LAYER Metal2 ;
  END done
  PIN device_control_write_enable 
    ANTENNAPARTIALMETALAREA 0.1052 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4734 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.26325 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 41.0255 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 187.195 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 7.31198 LAYER Via7 ;
  END device_control_write_enable
  PIN device_control_data[7] 
    ANTENNAPARTIALMETALAREA 1.9076 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.613 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 83.0026 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 375.631 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 2.38034 LAYER Via3 ;
  END device_control_data[7]
  PIN device_control_data[6] 
    ANTENNAPARTIALMETALAREA 1.3372 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.0174 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 130.637 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 588.779 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 2.89658 LAYER Via3 ;
  END device_control_data[6]
  PIN device_control_data[5] 
    ANTENNAPARTIALMETALAREA 0.0092 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0414 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 38.2197 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 188.903 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 34.8966 LAYER Via3 ;
  END device_control_data[5]
  PIN device_control_data[4] 
    ANTENNAPARTIALMETALAREA 1.2996 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.877 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 47.341 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 215.938 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 2.27436 LAYER Via3 ;
  END device_control_data[4]
  PIN device_control_data[3] 
    ANTENNAPARTIALMETALAREA 1.586 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.1658 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 57.1325 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 260 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 2.27436 LAYER Via3 ;
  END device_control_data[3]
  PIN device_control_data[2] 
    ANTENNAPARTIALMETALAREA 1.8916 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.541 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 100.367 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 453.477 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 2.27436 LAYER Via3 ;
  END device_control_data[2]
  PIN device_control_data[1] 
    ANTENNAPARTIALMETALAREA 0.9836 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.4262 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 10.0804 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 45.3276 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 385.16 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 1734.15 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 3.64188 LAYER Via4 ;
  END device_control_data[1]
  PIN device_control_data[0] 
    ANTENNAPARTIALMETALAREA 2.1412 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.6642 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 76.7017 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 348.01 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 2.34274 LAYER Via3 ;
  END device_control_data[0]
  PIN program_mem_read_valid[0] 
    ANTENNAPARTIALMETALAREA 0.5126 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.2752 LAYER Metal2 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via2 ;
    ANTENNAPARTIALMETALAREA 4.2664 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 19.2276 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.0564 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2196 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 0.0494 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2196 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNADIFFAREA 0.64145 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 5.8366 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 26.262 LAYER Metal6 ;
  END program_mem_read_valid[0]
  PIN program_mem_read_address[7] 
    ANTENNAPARTIALMETALAREA 0.7202 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.2094 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 1.6744 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 7.5636 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNADIFFAREA 0.64145 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 8.7124 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 39.1716 LAYER Metal6 ;
  END program_mem_read_address[7]
  PIN program_mem_read_address[6] 
    ANTENNADIFFAREA 0.34455 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 0.543 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 2.412 LAYER Metal6 ;
  END program_mem_read_address[6]
  PIN program_mem_read_address[5] 
    ANTENNAPARTIALMETALAREA 0.7376 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.3192 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 2.027 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 9.1188 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNADIFFAREA 0.64145 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 8.3628 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 37.5984 LAYER Metal6 ;
  END program_mem_read_address[5]
  PIN program_mem_read_address[4] 
    ANTENNADIFFAREA 0.64145 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 8.5578 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 38.4444 LAYER Metal6 ;
  END program_mem_read_address[4]
  PIN program_mem_read_address[3] 
    ANTENNAPARTIALMETALAREA 0.9686 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.3272 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 2.4744 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 11.1636 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNADIFFAREA 0.64145 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 8.4678 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 38.1024 LAYER Metal6 ;
  END program_mem_read_address[3]
  PIN program_mem_read_address[2] 
    ANTENNADIFFAREA 0.94375 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 11.125 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 49.9968 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.117 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 135.535 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 633.792 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 9.01709 LAYER Via6 ;
  END program_mem_read_address[2]
  PIN program_mem_read_address[1] 
    ANTENNAPARTIALMETALAREA 0.6038 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.6856 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 4.8264 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 21.7476 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNADIFFAREA 0.763375 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 11.6476 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 52.38 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 798.367 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 3598.15 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 5.89815 LAYER Via6 ;
  END program_mem_read_address[1]
  PIN program_mem_read_address[0] 
    ANTENNAPARTIALMETALAREA 0.727 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.24 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 4.6344 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 20.8836 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNADIFFAREA 0.64145 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 5.6436 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 25.362 LAYER Metal6 ;
  END program_mem_read_address[0]
  PIN program_mem_read_ready[0] 
    ANTENNAPARTIALMETALAREA 15.4628 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 69.5826 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0747 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 262.506 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 1185.39 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 4.22694 LAYER Via7 ;
  END program_mem_read_ready[0]
  PIN program_mem_read_data[15] 
    ANTENNAPARTIALMETALAREA 1.8652 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.3934 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 5.9498 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 26.7084 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0324 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 201.981 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 916.222 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 5.22222 LAYER Via4 ;
  END program_mem_read_data[15]
  PIN program_mem_read_data[14] 
    ANTENNAPARTIALMETALAREA 2.1372 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.6174 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 4.521 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 20.2788 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0324 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 172.006 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 781.333 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 5.22222 LAYER Via4 ;
  END program_mem_read_data[14]
  PIN program_mem_read_data[13] 
    ANTENNAPARTIALMETALAREA 1.4812 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.6654 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 3.7138 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 16.6464 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0324 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 134.253 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 611.444 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 5.22222 LAYER Via4 ;
  END program_mem_read_data[13]
  PIN program_mem_read_data[12] 
    ANTENNAPARTIALMETALAREA 1.7338 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.7994 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 114.074 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 522.667 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAMAXCUTCAR 5.22222 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 1.2036 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.382 LAYER Metal4 ;
    ANTENNAGATEAREA 0.0324 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 151.222 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 688.778 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 5.22222 LAYER Via4 ;
  END program_mem_read_data[12]
  PIN program_mem_read_data[11] 
    ANTENNAPARTIALMETALAREA 1.4812 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.6654 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0324 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 113.988 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 520.5 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 4.61728 LAYER Via3 ;
  END program_mem_read_data[11]
  PIN program_mem_read_data[10] 
    ANTENNAPARTIALMETALAREA 1.5116 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.8022 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 110.914 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 506.667 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAMAXCUTCAR 5.22222 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 1.962 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.7948 LAYER Metal4 ;
    ANTENNAGATEAREA 0.0324 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 171.469 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 778.111 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 5.22222 LAYER Via4 ;
  END program_mem_read_data[10]
  PIN program_mem_read_data[9] 
    ANTENNAPARTIALMETALAREA 1.6732 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.5294 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 111.457 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 509.111 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAMAXCUTCAR 5.22222 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 3.9198 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 17.6364 LAYER Metal4 ;
    ANTENNAGATEAREA 0.0324 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 232.438 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 1053.44 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 7.67284 LAYER Via4 ;
  END program_mem_read_data[9]
  PIN program_mem_read_data[8] 
    ANTENNAPARTIALMETALAREA 1.55 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.0326 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0324 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 316.099 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 1430.35 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 4.96296 LAYER Via3 ;
  END program_mem_read_data[8]
  PIN program_mem_read_data[7] 
    ANTENNAPARTIALMETALAREA 1.6996 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.677 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0162 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 110.679 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 509.333 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAMAXCUTCAR 5.22222 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 3.4212 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.3612 LAYER Metal4 ;
    ANTENNAGATEAREA 0.0324 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 216.272 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 983.444 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 5.22222 LAYER Via4 ;
  END program_mem_read_data[7]
  PIN program_mem_read_data[6] 
    ANTENNAPARTIALMETALAREA 1.3996 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.2982 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 8.3828 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 37.6884 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0324 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 278.259 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 1260.44 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 5.22222 LAYER Via4 ;
  END program_mem_read_data[6]
  PIN program_mem_read_data[5] 
    ANTENNAPARTIALMETALAREA 1.574 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.083 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 9.485 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 42.6168 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0324 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 307.34 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 1390.33 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 5.22222 LAYER Via4 ;
  END program_mem_read_data[5]
  PIN program_mem_read_data[4] 
    ANTENNAPARTIALMETALAREA 1.1756 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.2902 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 9.6546 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 43.4088 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0324 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 356.179 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 1611 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 5.82716 LAYER Via4 ;
  END program_mem_read_data[4]
  PIN program_mem_read_data[3] 
    ANTENNAPARTIALMETALAREA 1.0492 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.7214 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 12.3618 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 55.5912 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0324 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 431.833 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 1951.44 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 5.82716 LAYER Via4 ;
  END program_mem_read_data[3]
  PIN program_mem_read_data[2] 
    ANTENNAPARTIALMETALAREA 1.5772 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.0974 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 11.809 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 53.0748 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0324 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 397.537 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 1796.22 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 5.22222 LAYER Via4 ;
  END program_mem_read_data[2]
  PIN program_mem_read_data[1] 
    ANTENNAPARTIALMETALAREA 1.6732 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.5294 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 14.8818 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 66.9024 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0324 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 476.92 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 2153.44 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 5.22222 LAYER Via4 ;
  END program_mem_read_data[1]
  PIN program_mem_read_data[0] 
    ANTENNAPARTIALMETALAREA 7.8086 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 35.1072 LAYER Metal2 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via2 ;
    ANTENNAPARTIALMETALAREA 1.6744 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.5636 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 8.3024 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 37.2924 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0324 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 281.802 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 1275.33 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 5.82716 LAYER Via4 ;
  END program_mem_read_data[0]
  PIN data_mem_read_valid[3] 
    ANTENNADIFFAREA 0.34455 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 0.0092 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0414 LAYER Metal5 ;
  END data_mem_read_valid[3]
  PIN data_mem_read_valid[2] 
    ANTENNAPARTIALMETALAREA 0.0092 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0414 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.0924 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3816 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 0.782 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 9.3832 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 42.2532 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.117 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 99.6023 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 476.95 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 9.94815 LAYER Via5 ;
  END data_mem_read_valid[2]
  PIN data_mem_read_valid[1] 
    ANTENNAPARTIALMETALAREA 1.4476 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.5142 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 1.2476 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.58 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 0.48725 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 2.6184 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 11.8116 LAYER Metal5 ;
  END data_mem_read_valid[1]
  PIN data_mem_read_valid[0] 
    ANTENNADIFFAREA 0.34455 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 3.203 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 14.382 LAYER Metal4 ;
  END data_mem_read_valid[0]
  PIN data_mem_read_address[31] 
    ANTENNADIFFAREA 0.48725 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.695 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.096 LAYER Metal4 ;
  END data_mem_read_address[31]
  PIN data_mem_read_address[30] 
    ANTENNADIFFAREA 0.48725 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.8362 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.1972 LAYER Metal4 ;
  END data_mem_read_address[30]
  PIN data_mem_read_address[29] 
    ANTENNADIFFAREA 0.48725 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.467 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.07 LAYER Metal4 ;
  END data_mem_read_address[29]
  PIN data_mem_read_address[28] 
    ANTENNADIFFAREA 0.48725 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.1022 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4284 LAYER Metal4 ;
  END data_mem_read_address[28]
  PIN data_mem_read_address[27] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.163 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.702 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 29.9248 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 162.336 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.62255 LAYER Via4 ;
  END data_mem_read_address[27]
  PIN data_mem_read_address[26] 
    ANTENNADIFFAREA 0.34455 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.7406 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.3012 LAYER Metal4 ;
  END data_mem_read_address[26]
  PIN data_mem_read_address[25] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.049 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.1548 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 19.0401 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 113.291 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.5632 LAYER Via4 ;
  END data_mem_read_address[25]
  PIN data_mem_read_address[24] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.771 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 3.438 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 24.9247 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 139.782 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.5632 LAYER Via4 ;
  END data_mem_read_address[24]
  PIN data_mem_read_address[23] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.9534 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.2588 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 17.521 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 106.636 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.62273 LAYER Via4 ;
  END data_mem_read_address[23]
  PIN data_mem_read_address[22] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.9838 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.3956 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 17.0384 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 104.439 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.55472 LAYER Via4 ;
  END data_mem_read_address[22]
  PIN data_mem_read_address[21] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.0262 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0864 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 14.9911 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 95.3346 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.7668 LAYER Via4 ;
  END data_mem_read_address[21]
  PIN data_mem_read_address[20] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.0606 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.7412 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 13.5788 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 88.8535 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.5632 LAYER Via4 ;
  END data_mem_read_address[20]
  PIN data_mem_read_address[19] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.999 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.464 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 13.9196 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 90.4042 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.55472 LAYER Via4 ;
  END data_mem_read_address[19]
  PIN data_mem_read_address[18] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.9686 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.3272 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 14.5266 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 93.1361 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.55472 LAYER Via4 ;
  END data_mem_read_address[18]
  PIN data_mem_read_address[17] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.0262 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0864 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 13.3382 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 87.8582 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.73864 LAYER Via4 ;
  END data_mem_read_address[17]
  PIN data_mem_read_address[16] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.0262 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0864 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 13.353 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 87.89 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.61995 LAYER Via4 ;
  END data_mem_read_address[16]
  PIN data_mem_read_address[15] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.999 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.464 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 16.4744 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 101.883 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.56598 LAYER Via4 ;
  END data_mem_read_address[15]
  PIN data_mem_read_address[14] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.9382 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.1904 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 15.4355 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 97.226 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.55472 LAYER Via4 ;
  END data_mem_read_address[14]
  PIN data_mem_read_address[13] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.1662 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.2164 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 14.1666 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 91.5168 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.55194 LAYER Via4 ;
  END data_mem_read_address[13]
  PIN data_mem_read_address[12] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.999 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.464 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 13.6537 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 89.1675 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.72391 LAYER Via4 ;
  END data_mem_read_address[12]
  PIN data_mem_read_address[11] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.54 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.43 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 13.387 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 87.8811 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.55194 LAYER Via4 ;
  END data_mem_read_address[11]
  PIN data_mem_read_address[10] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.6646 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.9592 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 13.4105 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 88.1143 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.55194 LAYER Via4 ;
  END data_mem_read_address[10]
  PIN data_mem_read_address[9] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.4944 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.2248 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 13.0729 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 86.6295 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.61995 LAYER Via4 ;
  END data_mem_read_address[9]
  PIN data_mem_read_address[8] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.1022 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4284 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 13.3458 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 87.8229 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.55194 LAYER Via4 ;
  END data_mem_read_address[8]
  PIN data_mem_read_address[7] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.999 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.464 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 14.3439 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 92.349 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.61995 LAYER Via4 ;
  END data_mem_read_address[7]
  PIN data_mem_read_address[6] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.134 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.0688 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 15.3768 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 95.8075 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.56165 LAYER Via4 ;
  END data_mem_read_address[6]
  PIN data_mem_read_address[5] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.4718 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 6.5916 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 16.9185 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 103.96 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.67193 LAYER Via4 ;
  END data_mem_read_address[5]
  PIN data_mem_read_address[4] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.1206 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 5.0112 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 18.0287 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 108.881 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.77589 LAYER Via4 ;
  END data_mem_read_address[4]
  PIN data_mem_read_address[3] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.9574 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.7768 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 21.8885 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 126.224 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.72391 LAYER Via4 ;
  END data_mem_read_address[3]
  PIN data_mem_read_address[2] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.0782 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 9.3204 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 24.4052 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 137.581 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.54649 LAYER Via4 ;
  END data_mem_read_address[2]
  PIN data_mem_read_address[1] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.2646 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.1592 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 27.3526 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 150.815 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.60844 LAYER Via4 ;
  END data_mem_read_address[1]
  PIN data_mem_read_address[0] 
    ANTENNADIFFAREA 2.05512 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 2.291 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 10.278 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.24705 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 31.0804 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 167.628 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 8.55472 LAYER Via4 ;
  END data_mem_read_address[0]
  PIN data_mem_read_ready[3] 
    ANTENNAPARTIALMETALAREA 0.9702 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 4.3344 LAYER Metal6 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via6 ;
    ANTENNAPARTIALMETALAREA 1.0128 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 4.5864 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 186.721 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 843.179 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 3.27521 LAYER Via7 ;
  END data_mem_read_ready[3]
  PIN data_mem_read_ready[2] 
    ANTENNAPARTIALMETALAREA 0.9976 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 4.4892 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 22.2667 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 100.605 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 1.55556 LAYER Via6 ;
  END data_mem_read_ready[2]
  PIN data_mem_read_ready[1] 
    ANTENNAPARTIALMETALAREA 0.9656 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.3452 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 0.0494 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2196 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 0.0564 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2196 LAYER Metal6 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via6 ;
    ANTENNAPARTIALMETALAREA 0.0744 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3636 LAYER Metal7 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via7 ;
    ANTENNAPARTIALMETALAREA 3.026 LAYER Metal8 ;
    ANTENNAPARTIALMETALSIDEAREA 13.5828 LAYER Metal8 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal8 ; 
    ANTENNAMAXAREACAR 224.315 LAYER Metal8 ;
    ANTENNAMAXSIDEAREACAR 1011.18 LAYER Metal8 ;
    ANTENNAMAXCUTCAR 3.61026 LAYER Via8 ;
  END data_mem_read_ready[1]
  PIN data_mem_read_ready[0] 
    ANTENNAPARTIALMETALAREA 0.467 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.07 LAYER Metal2 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via2 ;
    ANTENNAPARTIALMETALAREA 1.5784 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.1316 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 6.8356 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 30.726 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 239.941 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 1081.31 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 2.27949 LAYER Via4 ;
  END data_mem_read_ready[0]
  PIN data_mem_read_data[31] 
    ANTENNAPARTIALMETALAREA 1.6868 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.5906 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.4572 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.0232 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 3.0934 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 13.9464 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.117 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 60.012 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 271.292 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAMAXCUTCAR 4.0812 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 0.6396 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 2.844 LAYER Metal6 ;
    ANTENNAGATEAREA 0.234 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 62.7453 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 283.446 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 4.0812 LAYER Via6 ;
  END data_mem_read_data[31]
  PIN data_mem_read_data[30] 
    ANTENNAPARTIALMETALAREA 0.0092 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0414 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 1.7932 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 8.064 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.234 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 108.181 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 486.01 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 4.54843 LAYER Via6 ;
  END data_mem_read_data[30]
  PIN data_mem_read_data[29] 
    ANTENNAPARTIALMETALAREA 0.0412 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1854 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 0.8206 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 3.69 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.234 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 81.2239 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 366.546 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 4.03932 LAYER Via6 ;
  END data_mem_read_data[29]
  PIN data_mem_read_data[28] 
    ANTENNAPARTIALMETALAREA 0.0732 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3294 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.1532 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6552 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 5.8488 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 26.3484 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.234 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 67.9106 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 306.965 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 3.99744 LAYER Via5 ;
  END data_mem_read_data[28]
  PIN data_mem_read_data[27] 
    ANTENNAPARTIALMETALAREA 3.2364 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 14.5638 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 1.4054 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 6.2244 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.234 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 69.9285 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 315.985 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 4.16496 LAYER Via6 ;
  END data_mem_read_data[27]
  PIN data_mem_read_data[26] 
    ANTENNAPARTIALMETALAREA 0.7292 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.2814 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.0564 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2196 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 4.9704 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 22.3956 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.234 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 65.2018 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 294.388 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 4.12051 LAYER Via5 ;
  END data_mem_read_data[26]
  PIN data_mem_read_data[25] 
    ANTENNAPARTIALMETALAREA 1.238 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.571 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.1076 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.45 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 4.8864 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 22.0176 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 97.6821 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 441.754 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAMAXCUTCAR 3.24786 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 1.6892 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 7.5672 LAYER Metal6 ;
    ANTENNAGATEAREA 0.234 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 104.901 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 474.092 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 3.52707 LAYER Via6 ;
  END data_mem_read_data[25]
  PIN data_mem_read_data[24] 
    ANTENNAPARTIALMETALAREA 0.9196 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.1382 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.062 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2448 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 3.5784 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 16.1316 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.234 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 61.0179 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 275.431 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 3.53675 LAYER Via5 ;
  END data_mem_read_data[24]
  PIN data_mem_read_data[23] 
    ANTENNAPARTIALMETALAREA 4.2852 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 19.3122 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 0.8844 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 3.9456 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.234 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 44.4299 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 203.749 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 5.86724 LAYER Via6 ;
  END data_mem_read_data[23]
  PIN data_mem_read_data[22] 
    ANTENNAPARTIALMETALAREA 0.1692 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.7614 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.4436 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.962 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 6.1856 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 27.864 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 115.374 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 524.01 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAMAXCUTCAR 2.87179 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 0.7612 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 3.3912 LAYER Metal6 ;
    ANTENNAGATEAREA 0.234 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 118.627 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 538.503 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 4.54815 LAYER Via6 ;
  END data_mem_read_data[22]
  PIN data_mem_read_data[21] 
    ANTENNAPARTIALMETALAREA 0.1052 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4734 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 2.664 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 11.9196 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.234 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 215.043 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 971.308 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 3.89744 LAYER Via6 ;
  END data_mem_read_data[21]
  PIN data_mem_read_data[20] 
    ANTENNAPARTIALMETALAREA 0.0732 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3294 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.1228 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.5184 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 7.3374 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 33.102 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.234 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 79.6744 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 362.938 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 3.56239 LAYER Via5 ;
  END data_mem_read_data[20]
  PIN data_mem_read_data[19] 
    ANTENNAPARTIALMETALAREA 6.4732 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 29.1582 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.234 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 71.3282 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 325.295 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 5.7208 LAYER Via5 ;
  END data_mem_read_data[19]
  PIN data_mem_read_data[18] 
    ANTENNAPARTIALMETALAREA 0.1372 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.6174 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.3964 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.7496 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 5.6536 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 25.47 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 80.5037 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 368.626 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAMAXCUTCAR 4.60399 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 0.7916 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 3.528 LAYER Metal6 ;
    ANTENNAGATEAREA 0.234 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 83.8866 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 383.703 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 4.60399 LAYER Via6 ;
  END data_mem_read_data[18]
  PIN data_mem_read_data[17] 
    ANTENNAPARTIALMETALAREA 0.0732 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.3294 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 1.6246 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 7.2396 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.234 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 226.341 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 1022.33 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 5.4849 LAYER Via6 ;
  END data_mem_read_data[17]
  PIN data_mem_read_data[16] 
    ANTENNAPARTIALMETALAREA 0.0182 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0504 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.5302 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.3832 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 4.5864 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 20.6676 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.234 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 87.1291 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 397.026 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 5.29886 LAYER Via5 ;
  END data_mem_read_data[16]
  PIN data_mem_read_data[15] 
    ANTENNAPARTIALMETALAREA 0.0412 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1854 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 16.5211 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 75.1009 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 0.778632 LAYER Via5 ;
  END data_mem_read_data[15]
  PIN data_mem_read_data[14] 
    ANTENNAPARTIALMETALAREA 1.4442 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.4962 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 17.5205 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 79.3538 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.64302 LAYER Via3 ;
  END data_mem_read_data[14]
  PIN data_mem_read_data[13] 
    ANTENNAPARTIALMETALAREA 0.1212 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.5454 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 14.0413 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 63.9419 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 0.778632 LAYER Via5 ;
  END data_mem_read_data[13]
  PIN data_mem_read_data[12] 
    ANTENNAPARTIALMETALAREA 1.3668 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.1506 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 16.5803 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 75.4291 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.555271 LAYER Via3 ;
  END data_mem_read_data[12]
  PIN data_mem_read_data[11] 
    ANTENNAPARTIALMETALAREA 3.5844 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 16.1586 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 80.3179 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 362.477 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 1.45641 LAYER Via5 ;
  END data_mem_read_data[11]
  PIN data_mem_read_data[10] 
    ANTENNAPARTIALMETALAREA 1.2076 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 5.4342 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 18.0957 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 81.9214 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 0.940171 LAYER Via5 ;
  END data_mem_read_data[10]
  PIN data_mem_read_data[9] 
    ANTENNAPARTIALMETALAREA 0.0412 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1854 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.2596 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.134 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 4.0744 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 18.3636 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 81.0427 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 366.026 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 1.31282 LAYER Via5 ;
  END data_mem_read_data[9]
  PIN data_mem_read_data[8] 
    ANTENNAPARTIALMETALAREA 1.474 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 6.6618 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 22.7923 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 103.761 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 1.10342 LAYER Via5 ;
  END data_mem_read_data[8]
  PIN data_mem_read_data[7] 
    ANTENNAPARTIALMETALAREA 1.5442 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.9174 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 19.6071 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 89.0496 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.555271 LAYER Via3 ;
  END data_mem_read_data[7]
  PIN data_mem_read_data[6] 
    ANTENNAPARTIALMETALAREA 1.4124 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.3558 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 16.9507 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 77.1795 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.64302 LAYER Via3 ;
  END data_mem_read_data[6]
  PIN data_mem_read_data[5] 
    ANTENNAPARTIALMETALAREA 1.0994 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.9158 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 15.4134 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 70.1778 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.555271 LAYER Via3 ;
  END data_mem_read_data[5]
  PIN data_mem_read_data[4] 
    ANTENNAPARTIALMETALAREA 3.9428 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 17.7426 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 74.212 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 334.795 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 1.31282 LAYER Via5 ;
  END data_mem_read_data[4]
  PIN data_mem_read_data[3] 
    ANTENNAPARTIALMETALAREA 3.6486 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 16.416 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 64 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 288.6 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 1.12137 LAYER Via3 ;
  END data_mem_read_data[3]
  PIN data_mem_read_data[2] 
    ANTENNAPARTIALMETALAREA 0.3924 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 1.7658 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 14.2667 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 64.6906 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 0.940171 LAYER Via5 ;
  END data_mem_read_data[2]
  PIN data_mem_read_data[1] 
    ANTENNAPARTIALMETALAREA 1.4338 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.4206 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 17.1248 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 77.6137 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.716809 LAYER Via3 ;
  END data_mem_read_data[1]
  PIN data_mem_read_data[0] 
    ANTENNAPARTIALMETALAREA 1.0156 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.5702 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 12.4048 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 56.6393 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 0.555271 LAYER Via3 ;
  END data_mem_read_data[0]
  PIN data_mem_write_valid[3] 
    ANTENNADIFFAREA 0.34455 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 2.8572 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 12.8574 LAYER Metal5 ;
  END data_mem_write_valid[3]
  PIN data_mem_write_valid[2] 
    ANTENNADIFFAREA 0.572 LAYER Metal2 ; 
    ANTENNAPARTIALMETALAREA 2.0548 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 9.2124 LAYER Metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0747 LAYER Metal2 ; 
    ANTENNAMAXAREACAR 36.7757 LAYER Metal2 ;
    ANTENNAMAXSIDEAREACAR 195.505 LAYER Metal2 ;
    ANTENNAMAXCUTCAR 9.4359 LAYER Via2 ;
  END data_mem_write_valid[2]
  PIN data_mem_write_valid[1] 
    ANTENNADIFFAREA 2.05512 LAYER Metal2 ; 
    ANTENNAPARTIALMETALAREA 1.212 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.454 LAYER Metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.28935 LAYER Metal2 ; 
    ANTENNAMAXAREACAR 12.6188 LAYER Metal2 ;
    ANTENNAMAXSIDEAREACAR 84.5736 LAYER Metal2 ;
    ANTENNAMAXCUTCAR 8.4726 LAYER Via2 ;
  END data_mem_write_valid[1]
  PIN data_mem_write_valid[0] 
    ANTENNADIFFAREA 0.64145 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 3.9132 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 17.6094 LAYER Metal5 ;
  END data_mem_write_valid[0]
  PIN data_mem_write_address[31] 
    ANTENNADIFFAREA 0.48725 LAYER Metal7 ; 
    ANTENNAPARTIALMETALAREA 2.4732 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 11.1294 LAYER Metal7 ;
  END data_mem_write_address[31]
  PIN data_mem_write_address[30] 
    ANTENNADIFFAREA 0.34455 LAYER Metal2 ; 
    ANTENNAPARTIALMETALAREA 1.2486 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.616 LAYER Metal2 ;
  END data_mem_write_address[30]
  PIN data_mem_write_address[29] 
    ANTENNADIFFAREA 0.34455 LAYER Metal2 ; 
    ANTENNAPARTIALMETALAREA 2.9124 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 13.0716 LAYER Metal2 ;
  END data_mem_write_address[29]
  PIN data_mem_write_address[28] 
    ANTENNAPARTIALMETALAREA 3.641 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 16.353 LAYER Metal2 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via2 ;
    ANTENNADIFFAREA 0.34455 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.5704 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.5956 LAYER Metal3 ;
  END data_mem_write_address[28]
  PIN data_mem_write_address[27] 
    ANTENNADIFFAREA 0.34455 LAYER Metal2 ; 
    ANTENNAPARTIALMETALAREA 1.0222 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.5972 LAYER Metal2 ;
  END data_mem_write_address[27]
  PIN data_mem_write_address[26] 
    ANTENNAPARTIALMETALAREA 0.0262 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 0.0864 LAYER Metal2 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via2 ;
    ANTENNAPARTIALMETALAREA 0.5864 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.6676 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.0382 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1692 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 0.0494 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 0.2196 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNADIFFAREA 0.34455 LAYER Metal6 ; 
    ANTENNAPARTIALMETALAREA 2.7646 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 12.438 LAYER Metal6 ;
  END data_mem_write_address[26]
  PIN data_mem_write_address[25] 
    ANTENNAPARTIALMETALAREA 0.695 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 3.096 LAYER Metal2 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via2 ;
    ANTENNAPARTIALMETALAREA 9.8824 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 44.4996 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 0.763375 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 4.4726 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 20.124 LAYER Metal4 ;
  END data_mem_write_address[25]
  PIN data_mem_write_address[24] 
    ANTENNAPARTIALMETALAREA 0.6342 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.8224 LAYER Metal2 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via2 ;
    ANTENNAPARTIALMETALAREA 6.0904 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 27.4356 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 0.64145 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 3.438 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.4368 LAYER Metal4 ;
  END data_mem_write_address[24]
  PIN data_mem_write_address[23] 
    ANTENNADIFFAREA 0.572 LAYER Metal2 ; 
    ANTENNAPARTIALMETALAREA 1.6842 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 7.5132 LAYER Metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal2 ; 
    ANTENNAMAXAREACAR 38.0581 LAYER Metal2 ;
    ANTENNAMAXSIDEAREACAR 200.61 LAYER Metal2 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via2 ;
    ANTENNAMAXCUTCAR 9.60342 LAYER Via2 ;
    ANTENNADIFFAREA 0.572 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.3326 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.494 LAYER Metal3 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 41.8484 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 217.636 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 9.60342 LAYER Via3 ;
  END data_mem_write_address[23]
  PIN data_mem_write_address[22] 
    ANTENNADIFFAREA 0.572 LAYER Metal2 ; 
    ANTENNAPARTIALMETALAREA 1.1066 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.914 LAYER Metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal2 ; 
    ANTENNAMAXAREACAR 28.1744 LAYER Metal2 ;
    ANTENNAMAXSIDEAREACAR 156.128 LAYER Metal2 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via2 ;
    ANTENNAMAXCUTCAR 9.59316 LAYER Via2 ;
    ANTENNADIFFAREA 0.572 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.2824 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.2996 LAYER Metal3 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 31.3926 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 170.938 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 9.59316 LAYER Via3 ;
  END data_mem_write_address[22]
  PIN data_mem_write_address[21] 
    ANTENNAPARTIALMETALAREA 1.37 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 6.1308 LAYER Metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal2 ; 
    ANTENNAMAXAREACAR 48.135 LAYER Metal2 ;
    ANTENNAMAXSIDEAREACAR 218.164 LAYER Metal2 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via2 ;
    ANTENNAMAXCUTCAR 1.96752 LAYER Via2 ;
    ANTENNADIFFAREA 0.572 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.3784 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.7316 LAYER Metal3 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 52.4473 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 237.897 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 9.59316 LAYER Via3 ;
  END data_mem_write_address[21]
  PIN data_mem_write_address[20] 
    ANTENNADIFFAREA 0.572 LAYER Metal2 ; 
    ANTENNAPARTIALMETALAREA 1.3978 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 6.2244 LAYER Metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal2 ; 
    ANTENNAMAXAREACAR 25.1875 LAYER Metal2 ;
    ANTENNAMAXSIDEAREACAR 143.062 LAYER Metal2 ;
    ANTENNAMAXCUTCAR 9.42564 LAYER Via2 ;
  END data_mem_write_address[20]
  PIN data_mem_write_address[19] 
    ANTENNADIFFAREA 0.572 LAYER Metal2 ; 
    ANTENNAPARTIALMETALAREA 1.4532 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 6.5052 LAYER Metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal2 ; 
    ANTENNAMAXAREACAR 25.8188 LAYER Metal2 ;
    ANTENNAMAXSIDEAREACAR 146.262 LAYER Metal2 ;
    ANTENNAMAXCUTCAR 9.42564 LAYER Via2 ;
  END data_mem_write_address[19]
  PIN data_mem_write_address[18] 
    ANTENNADIFFAREA 0.572 LAYER Metal2 ; 
    ANTENNAPARTIALMETALAREA 1.5338 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 6.8364 LAYER Metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal2 ; 
    ANTENNAMAXAREACAR 35.4769 LAYER Metal2 ;
    ANTENNAMAXSIDEAREACAR 188.99 LAYER Metal2 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via2 ;
    ANTENNAMAXCUTCAR 9.59316 LAYER Via2 ;
    ANTENNADIFFAREA 0.572 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.3936 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.8 LAYER Metal3 ;
    ANTENNAGATEAREA 0.117 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 38.841 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 204.374 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 9.59316 LAYER Via3 ;
  END data_mem_write_address[18]
  PIN data_mem_write_address[17] 
    ANTENNAPARTIALMETALAREA 0.5734 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 2.5488 LAYER Metal2 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via2 ;
    ANTENNAPARTIALMETALAREA 4.129 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 18.5778 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 0.572 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.967 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 4.3488 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.117 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 20.7282 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 123.877 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 9.58974 LAYER Via4 ;
  END data_mem_write_address[17]
  PIN data_mem_write_address[16] 
    ANTENNAPARTIALMETALAREA 1.1118 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.0004 LAYER Metal2 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER Via2 ;
    ANTENNAPARTIALMETALAREA 0.02 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.1188 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0049 LAYER Via3 ;
    ANTENNADIFFAREA 0.572 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.0864 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4176 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 17.0917 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 108.005 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 9.53732 LAYER Via4 ;
  END data_mem_write_address[16]
  PIN data_mem_write_address[15] 
    ANTENNAPARTIALMETALAREA 1.1222 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.0184 LAYER Metal2 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via2 ;
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.7928 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 3.5964 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 11.9434 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 81.6334 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.51505 LAYER Via3 ;
  END data_mem_write_address[15]
  PIN data_mem_write_address[14] 
    ANTENNADIFFAREA 2.05512 LAYER Metal2 ; 
    ANTENNAPARTIALMETALAREA 1.1804 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.2776 LAYER Metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal2 ; 
    ANTENNAMAXAREACAR 12.9602 LAYER Metal2 ;
    ANTENNAMAXSIDEAREACAR 85.9697 LAYER Metal2 ;
    ANTENNAMAXCUTCAR 8.46437 LAYER Via2 ;
  END data_mem_write_address[14]
  PIN data_mem_write_address[13] 
    ANTENNAPARTIALMETALAREA 1.0454 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.6728 LAYER Metal2 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via2 ;
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.2024 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.9396 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 9.72734 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 71.6622 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.51028 LAYER Via3 ;
  END data_mem_write_address[13]
  PIN data_mem_write_address[12] 
    ANTENNAPARTIALMETALAREA 1.0357 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.6224 LAYER Metal2 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via2 ;
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.1336 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.63 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 9.1162 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 68.9108 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.51505 LAYER Via3 ;
  END data_mem_write_address[12]
  PIN data_mem_write_address[11] 
    ANTENNADIFFAREA 2.05512 LAYER Metal2 ; 
    ANTENNAPARTIALMETALAREA 1.2796 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.7582 LAYER Metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal2 ; 
    ANTENNAMAXAREACAR 13.3498 LAYER Metal2 ;
    ANTENNAMAXSIDEAREACAR 87.8629 LAYER Metal2 ;
    ANTENNAMAXCUTCAR 8.4726 LAYER Via2 ;
  END data_mem_write_address[11]
  PIN data_mem_write_address[10] 
    ANTENNAPARTIALMETALAREA 1.0426 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.6602 LAYER Metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal2 ; 
    ANTENNAMAXAREACAR 38.3761 LAYER Metal2 ;
    ANTENNAMAXSIDEAREACAR 175.99 LAYER Metal2 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via2 ;
    ANTENNAMAXCUTCAR 3.40171 LAYER Via2 ;
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.2504 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.1556 LAYER Metal3 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 39.3388 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 180.433 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.52632 LAYER Via3 ;
  END data_mem_write_address[10]
  PIN data_mem_write_address[9] 
    ANTENNADIFFAREA 2.05512 LAYER Metal2 ; 
    ANTENNAPARTIALMETALAREA 1.0912 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.8762 LAYER Metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal2 ; 
    ANTENNAMAXAREACAR 13.0833 LAYER Metal2 ;
    ANTENNAMAXSIDEAREACAR 86.7981 LAYER Metal2 ;
    ANTENNAMAXCUTCAR 8.97293 LAYER Via2 ;
  END data_mem_write_address[9]
  PIN data_mem_write_address[8] 
    ANTENNAPARTIALMETALAREA 1.0294 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 4.6008 LAYER Metal2 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via2 ;
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.2968 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 1.3644 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 9.81556 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 72.0579 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.51505 LAYER Via3 ;
  END data_mem_write_address[8]
  PIN data_mem_write_address[7] 
    ANTENNADIFFAREA 2.05512 LAYER Metal2 ; 
    ANTENNAPARTIALMETALAREA 1.2374 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.5656 LAYER Metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal2 ; 
    ANTENNAMAXAREACAR 13.1876 LAYER Metal2 ;
    ANTENNAMAXSIDEAREACAR 87.1224 LAYER Metal2 ;
    ANTENNAMAXCUTCAR 8.4726 LAYER Via2 ;
  END data_mem_write_address[7]
  PIN data_mem_write_address[6] 
    ANTENNADIFFAREA 2.05512 LAYER Metal2 ; 
    ANTENNAPARTIALMETALAREA 1.2322 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.5134 LAYER Metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal2 ; 
    ANTENNAMAXAREACAR 13.1788 LAYER Metal2 ;
    ANTENNAMAXSIDEAREACAR 86.9542 LAYER Metal2 ;
    ANTENNAMAXCUTCAR 8.48386 LAYER Via2 ;
  END data_mem_write_address[6]
  PIN data_mem_write_address[5] 
    ANTENNADIFFAREA 2.05512 LAYER Metal2 ; 
    ANTENNAPARTIALMETALAREA 1.2533 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.5674 LAYER Metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal2 ; 
    ANTENNAMAXAREACAR 13.3687 LAYER Metal2 ;
    ANTENNAMAXSIDEAREACAR 87.8571 LAYER Metal2 ;
    ANTENNAMAXCUTCAR 8.59259 LAYER Via2 ;
  END data_mem_write_address[5]
  PIN data_mem_write_address[4] 
    ANTENNADIFFAREA 2.05512 LAYER Metal2 ; 
    ANTENNAPARTIALMETALAREA 1.154 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.13 LAYER Metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal2 ; 
    ANTENNAMAXAREACAR 15.4248 LAYER Metal2 ;
    ANTENNAMAXSIDEAREACAR 85.9155 LAYER Metal2 ;
    ANTENNAMAXCUTCAR 11.3231 LAYER Via2 ;
  END data_mem_write_address[4]
  PIN data_mem_write_address[3] 
    ANTENNADIFFAREA 2.05512 LAYER Metal2 ; 
    ANTENNAPARTIALMETALAREA 1.2538 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.6052 LAYER Metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal2 ; 
    ANTENNAMAXAREACAR 13.2506 LAYER Metal2 ;
    ANTENNAMAXSIDEAREACAR 87.2747 LAYER Metal2 ;
    ANTENNAMAXCUTCAR 8.4726 LAYER Via2 ;
  END data_mem_write_address[3]
  PIN data_mem_write_address[2] 
    ANTENNAPARTIALMETALAREA 1.303 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 5.832 LAYER Metal2 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via2 ;
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.5384 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 2.4516 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 11.0891 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 77.6691 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.51028 LAYER Via3 ;
  END data_mem_write_address[2]
  PIN data_mem_write_address[1] 
    ANTENNADIFFAREA 2.05512 LAYER Metal2 ; 
    ANTENNAPARTIALMETALAREA 2.2648 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 10.1574 LAYER Metal2 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal2 ; 
    ANTENNAMAXAREACAR 17.1488 LAYER Metal2 ;
    ANTENNAMAXSIDEAREACAR 104.809 LAYER Metal2 ;
    ANTENNAMAXCUTCAR 8.48386 LAYER Via2 ;
  END data_mem_write_address[1]
  PIN data_mem_write_address[0] 
    ANTENNADIFFAREA 2.05512 LAYER Metal7 ; 
    ANTENNAPARTIALMETALAREA 2.0252 LAYER Metal7 ;
    ANTENNAPARTIALMETALSIDEAREA 9.1134 LAYER Metal7 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal7 ; 
    ANTENNAMAXAREACAR 25.4831 LAYER Metal7 ;
    ANTENNAMAXSIDEAREACAR 142.682 LAYER Metal7 ;
    ANTENNAMAXCUTCAR 8.755 LAYER Via7 ;
  END data_mem_write_address[0]
  PIN data_mem_write_data[31] 
    ANTENNAPARTIALMETALAREA 4.8142 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 21.6324 LAYER Metal2 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via2 ;
    ANTENNADIFFAREA 0.572 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 2.8248 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.7404 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 58.4 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 293.718 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 9.60342 LAYER Via3 ;
  END data_mem_write_data[31]
  PIN data_mem_write_data[30] 
    ANTENNAPARTIALMETALAREA 2.7132 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.2094 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 2.9044 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 13.0356 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 0.572 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 0.9656 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 4.374 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 28.2927 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 159.144 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 9.65342 LAYER Via5 ;
  END data_mem_write_data[30]
  PIN data_mem_write_data[29] 
    ANTENNAPARTIALMETALAREA 2.5372 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.4174 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 0.572 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 4.3788 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 19.6704 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 78.3043 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 382.374 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 9.7151 LAYER Via4 ;
  END data_mem_write_data[29]
  PIN data_mem_write_data[28] 
    ANTENNAPARTIALMETALAREA 2.6012 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 11.7054 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 0.572 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 3.5428 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.9084 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 66.5185 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 329.697 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 9.7151 LAYER Via4 ;
  END data_mem_write_data[28]
  PIN data_mem_write_data[27] 
    ANTENNAPARTIALMETALAREA 2.6804 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.0618 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 0.572 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 3.3924 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 15.2316 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 63.1772 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 314.662 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 9.7151 LAYER Via4 ;
  END data_mem_write_data[27]
  PIN data_mem_write_data[26] 
    ANTENNAPARTIALMETALAREA 1.3852 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.2334 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAPARTIALMETALAREA 0.3508 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.5444 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNADIFFAREA 0.572 LAYER Metal5 ; 
    ANTENNAPARTIALMETALAREA 2.6344 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 11.8836 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 68.9795 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 341.067 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 9.6735 LAYER Via5 ;
  END data_mem_write_data[26]
  PIN data_mem_write_data[25] 
    ANTENNAPARTIALMETALAREA 2.7444 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.3498 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 0.572 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.7508 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 7.8444 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 48.4067 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 248.446 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 9.59758 LAYER Via4 ;
  END data_mem_write_data[25]
  PIN data_mem_write_data[24] 
    ANTENNAPARTIALMETALAREA 2.7612 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.4254 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNADIFFAREA 0.572 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 1.9064 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 8.5104 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 50.604 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 257.81 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 10.106 LAYER Via4 ;
  END data_mem_write_data[24]
  PIN data_mem_write_data[23] 
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.1052 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.4734 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 13.2036 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 88.6618 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 11.919 LAYER Via3 ;
  END data_mem_write_data[23]
  PIN data_mem_write_data[22] 
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.1876 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.373 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.28935 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 13.6573 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 89.3164 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.54754 LAYER Via3 ;
  END data_mem_write_data[22]
  PIN data_mem_write_data[21] 
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.2012 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.9054 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 28.1741 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 141.903 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 26.6496 LAYER Via3 ;
  END data_mem_write_data[21]
  PIN data_mem_write_data[20] 
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.9636 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.365 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.28935 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 13.6993 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 89.4819 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.54754 LAYER Via3 ;
  END data_mem_write_data[20]
  PIN data_mem_write_data[19] 
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.9956 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 4.509 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.28935 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 12.9422 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 86.0965 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.52805 LAYER Via3 ;
  END data_mem_write_data[19]
  PIN data_mem_write_data[18] 
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.1132 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.0094 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 13.299 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 87.503 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.51028 LAYER Via3 ;
  END data_mem_write_data[18]
  PIN data_mem_write_data[17] 
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.1612 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.2254 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 13.5533 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 88.629 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.52154 LAYER Via3 ;
  END data_mem_write_data[17]
  PIN data_mem_write_data[16] 
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.1932 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.3694 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 14.7672 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 94.1012 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.50205 LAYER Via3 ;
  END data_mem_write_data[16]
  PIN data_mem_write_data[15] 
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.2556 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.6502 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 13.7765 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 89.7713 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.51505 LAYER Via3 ;
  END data_mem_write_data[15]
  PIN data_mem_write_data[14] 
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.1132 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.0094 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.28935 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 13.4527 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 88.5057 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.61213 LAYER Via3 ;
  END data_mem_write_data[14]
  PIN data_mem_write_data[13] 
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.2116 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.981 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.28935 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 14.9301 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 96.66 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 12.0182 LAYER Via3 ;
  END data_mem_write_data[13]
  PIN data_mem_write_data[12] 
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.1212 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.5454 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 14.9106 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 96.262 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 11.8168 LAYER Via3 ;
  END data_mem_write_data[12]
  PIN data_mem_write_data[11] 
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.2412 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 5.5854 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 16.5914 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 102.396 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.95776 LAYER Via3 ;
  END data_mem_write_data[11]
  PIN data_mem_write_data[10] 
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 3.2404 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 14.6394 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 21.0782 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 122.85 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.51505 LAYER Via3 ;
  END data_mem_write_data[10]
  PIN data_mem_write_data[9] 
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 2.8004 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 12.6306 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 24.5837 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 115.127 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.51505 LAYER Via3 ;
  END data_mem_write_data[9]
  PIN data_mem_write_data[8] 
    ANTENNADIFFAREA 2.05512 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.698 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.6698 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.2601 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 16.193 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 100.74 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 8.52154 LAYER Via3 ;
  END data_mem_write_data[8]
  PIN data_mem_write_data[7] 
    ANTENNADIFFAREA 0.572 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.5188 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.8634 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 27.2467 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 153.359 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 9.59316 LAYER Via3 ;
  END data_mem_write_data[7]
  PIN data_mem_write_data[6] 
    ANTENNADIFFAREA 0.572 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 2.2916 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 10.341 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 51.5179 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 262.744 LAYER Metal3 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via3 ;
    ANTENNAMAXCUTCAR 9.76068 LAYER Via3 ;
    ANTENNADIFFAREA 0.572 LAYER Metal4 ; 
    ANTENNAPARTIALMETALAREA 0.3326 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 1.494 LAYER Metal4 ;
    ANTENNAGATEAREA 0.117 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 54.3607 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 275.513 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 9.76068 LAYER Via4 ;
  END data_mem_write_data[6]
  PIN data_mem_write_data[5] 
    ANTENNADIFFAREA 0.572 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.5188 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 6.8634 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.117 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 25.9197 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 147.333 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 9.51966 LAYER Via3 ;
  END data_mem_write_data[5]
  PIN data_mem_write_data[4] 
    ANTENNADIFFAREA 0.572 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.9036 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.595 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 129.803 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 614.323 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 9.76068 LAYER Via3 ;
  END data_mem_write_data[4]
  PIN data_mem_write_data[3] 
    ANTENNADIFFAREA 0.572 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 2.03 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 9.1926 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 39.6194 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 208.826 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 9.76068 LAYER Via3 ;
  END data_mem_write_data[3]
  PIN data_mem_write_data[2] 
    ANTENNADIFFAREA 0.572 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.586 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 7.1658 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 31.0051 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 169.903 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 9.54758 LAYER Via3 ;
  END data_mem_write_data[2]
  PIN data_mem_write_data[1] 
    ANTENNADIFFAREA 0.572 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 0.1316 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 0.621 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 244.965 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 1102.98 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 9.59316 LAYER Via3 ;
  END data_mem_write_data[1]
  PIN data_mem_write_data[0] 
    ANTENNAPARTIALMETALAREA 7.8398 LAYER Metal2 ;
    ANTENNAPARTIALMETALSIDEAREA 35.2476 LAYER Metal2 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via2 ;
    ANTENNADIFFAREA 0.572 LAYER Metal3 ; 
    ANTENNAPARTIALMETALAREA 1.8336 LAYER Metal3 ;
    ANTENNAPARTIALMETALSIDEAREA 8.28 LAYER Metal3 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.08775 LAYER Metal3 ; 
    ANTENNAMAXAREACAR 30.8342 LAYER Metal3 ;
    ANTENNAMAXSIDEAREACAR 169.503 LAYER Metal3 ;
    ANTENNAMAXCUTCAR 9.59316 LAYER Via3 ;
  END data_mem_write_data[0]
  PIN data_mem_write_ready[3] 
    ANTENNAPARTIALMETALAREA 1.379 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 6.174 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 8.2952 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 37.3572 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 4.3364 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 19.4796 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 261.026 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 1176.45 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 4.35641 LAYER Via6 ;
  END data_mem_write_ready[3]
  PIN data_mem_write_ready[2] 
    ANTENNAPARTIALMETALAREA 0.467 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 2.07 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 1.3224 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 5.9796 LAYER Metal5 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via5 ;
    ANTENNAPARTIALMETALAREA 7.422 LAYER Metal6 ;
    ANTENNAPARTIALMETALSIDEAREA 33.3648 LAYER Metal6 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal6 ; 
    ANTENNAMAXAREACAR 300.906 LAYER Metal6 ;
    ANTENNAMAXSIDEAREACAR 1356.4 LAYER Metal6 ;
    ANTENNAMAXCUTCAR 4.03077 LAYER Via6 ;
  END data_mem_write_ready[2]
  PIN data_mem_write_ready[1] 
    ANTENNAPARTIALMETALAREA 3.8762 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 17.3772 LAYER Metal4 ;
    ANTENNAPARTIALCUTAREA 0.0098 LAYER Via4 ;
    ANTENNAPARTIALMETALAREA 1.4648 LAYER Metal5 ;
    ANTENNAPARTIALMETALSIDEAREA 6.6204 LAYER Metal5 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.02925 LAYER Metal5 ; 
    ANTENNAMAXAREACAR 179.002 LAYER Metal5 ;
    ANTENNAMAXSIDEAREACAR 807.569 LAYER Metal5 ;
    ANTENNAMAXCUTCAR 2.74872 LAYER Via5 ;
  END data_mem_write_ready[1]
  PIN data_mem_write_ready[0] 
    ANTENNAPARTIALMETALAREA 7.085 LAYER Metal4 ;
    ANTENNAPARTIALMETALSIDEAREA 31.8168 LAYER Metal4 ;
    ANTENNAMODEL OXIDE1 ;
    ANTENNAGATEAREA 0.0585 LAYER Metal4 ; 
    ANTENNAMAXAREACAR 132.379 LAYER Metal4 ;
    ANTENNAMAXSIDEAREACAR 596.882 LAYER Metal4 ;
    ANTENNAMAXCUTCAR 3.55214 LAYER Via4 ;
  END data_mem_write_ready[0]
END gpu

END LIBRARY
